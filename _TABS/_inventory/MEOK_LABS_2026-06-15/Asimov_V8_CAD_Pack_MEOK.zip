STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:45',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 1
Bounding box: 80 x 3 x 60 mm (x, y, z)
Volume: 14318.3 mm3; surface area: 10481.7 mm2
Topology: 1 solids, 1 shells, 9 faces, 21 edges, 14 vertices
Faces by surface type: plane 6, cylinder 3
Full cylindrical faces by diameter (mm): 3.4 x3
Entity records: 556 total; most frequent: DIRECTION 89, CARTESIAN_POINT 87, LINE 51, VECTOR 51, ORIENTED_EDGE 42, PCURVE 42, DEFINITIONAL_REPRESENTATION 42, EDGE_CURVE 21
