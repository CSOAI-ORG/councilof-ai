STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:26:43',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 10
Bounding box: 50 x 50 x 4 mm (x, y, z)
Volume: 3287.1 mm3; surface area: 2804.7 mm2
Topology: 1 solids, 1 shells, 6 faces, 12 edges, 8 vertices
Faces by surface type: cylinder 4, plane 2
Full cylindrical faces by diameter (mm): 2.2 x2, 38 x1, 50 x1
Entity records: 342 total; most frequent: DIRECTION 58, CARTESIAN_POINT 51, ORIENTED_EDGE 24, PCURVE 24, DEFINITIONAL_REPRESENTATION 24, LINE 20, VECTOR 20, CIRCLE 16
