STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:21',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 1
Bounding box: 180 x 50 x 75 mm (x, y, z)
Volume: 86090 mm3; surface area: 28967.5 mm2
Topology: 1 solids, 1 shells, 43 faces, 107 edges, 70 vertices
Faces by surface type: plane 30, cylinder 13
Full cylindrical faces by diameter (mm): 5.5 x4, 10 x4, 30 x1
Entity records: 2721 total; most frequent: CARTESIAN_POINT 477, DIRECTION 432, LINE 261, VECTOR 261, ORIENTED_EDGE 214, PCURVE 214, DEFINITIONAL_REPRESENTATION 214, EDGE_CURVE 107
