STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:45',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 9
Bounding box: 60 x 30 x 10 mm (x, y, z)
Volume: 17541 mm3; surface area: 5672.3 mm2
Topology: 1 solids, 1 shells, 16 faces, 33 edges, 22 vertices
Faces by surface type: plane 9, cylinder 7
Full cylindrical faces by diameter (mm): 4.5 x3
Entity records: 891 total; most frequent: CARTESIAN_POINT 180, DIRECTION 140, LINE 71, VECTOR 71, ORIENTED_EDGE 66, PCURVE 66, DEFINITIONAL_REPRESENTATION 66, EDGE_CURVE 33
