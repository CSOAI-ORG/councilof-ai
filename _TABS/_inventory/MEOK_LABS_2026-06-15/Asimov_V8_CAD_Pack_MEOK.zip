STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:23',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 4
Bounding box: 40 x 40 x 3 mm (x, y, z)
Volume: 2607.4 mm3; surface area: 2660.1 mm2
Topology: 1 solids, 1 shells, 26 faces, 60 edges, 36 vertices
Faces by surface type: cylinder 13, cone 7, plane 6
Full cylindrical faces by diameter (mm): 4.5 x4, 8 x1, 17 x1, 40 x1
Entity records: 2017 total; most frequent: CARTESIAN_POINT 805, DIRECTION 225, ORIENTED_EDGE 122, PCURVE 120, DEFINITIONAL_REPRESENTATION 120, LINE 81, VECTOR 81, AXIS2_PLACEMENT_3D 63
