One B-rep face of a CAD part: STEP entity #17.
In plain terms, this cylindrical face has radius 20 mm (diameter 40 mm), a full revolution.
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#17 = ADVANCED_FACE('',(#18),#31,.T.);
#18 = FACE_BOUND('',#19,.F.);
#19 = EDGE_LOOP('',(#20,#54,#77,#105,#134,#163,#192,#219,#220));
#20 = ORIENTED_EDGE('',*,*,#21,.F.);
#21 = EDGE_CURVE('',#22,#22,#24,.T.);
#22 = VERTEX_POINT('',#23);
#23 = CARTESIAN_POINT('',(20.,0.,0.3));
#24 = SURFACE_CURVE('',#25,(#30,#42),.PCURVE_S1.);
#25 = CIRCLE('',#26,20.);
#26 = AXIS2_PLACEMENT_3D('',#27,#28,#29);
#27 = CARTESIAN_POINT('',(0.,0.,0.3));
#28 = DIRECTION('',(0.,0.,1.));
#29 = DIRECTION('',(1.,0.,-0.));
#30 = PCURVE('',#31,#36);
#31 = CYLINDRICAL_SURFACE('',#32,20.);
#32 = AXIS2_PLACEMENT_3D('',#33,#34,#35);
#33 = CARTESIAN_POINT('',(0.,0.,0.));
#34 = DIRECTION('',(-0.,-0.,-1.));
#35 = DIRECTION('',(1.,0.,0.));
#36 = DEFINITIONAL_REPRESENTATION('',(#37),#41);
#37 = LINE('',#38,#39);
#38 = CARTESIAN_POINT('',(-0.,-0.3));
#39 = VECTOR('',#40,1.);
#40 = DIRECTION('',(-1.,0.));
#41 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#42 = PCURVE('',#43,#48);
#43 = CONICAL_SURFACE('',#44,20.,0.785);
#44 = AXIS2_PLACEMENT_3D('',#45,#46,#47);
#45 = CARTESIAN_POINT('',(0.,0.,0.3));
#46 = DIRECTION('',(0.,0.,1.));
#47 = DIRECTION('',(1.,0.,-0.));
#48 = DEFINITIONAL_REPRESENTATION('',(#49),#53);
#49 = LINE('',#50,#51);
#50 = CARTESIAN_POINT('',(0.,-0.));
#51 = VECTOR('',#52,1.);
#52 = DIRECTION('',(1.,-0.));
#53 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#54 = ORIENTED_EDGE('',*,*,#55,.T.);
#55 = EDGE_CURVE('',#22,#56,#58,.T.);
#56 = VERTEX_POINT('',#57);
#57 = CARTESIAN_POINT('',(20.,0.,1.));
#58 = SEAM_CURVE('',#59,(#63,#70),.PCURVE_S1.);
#59 = LINE('',#60,#61);
#60 = CARTESIAN_POINT('',(20.,0.,0.));
#61 = VECTOR('',#62,1.);
#62 = DIRECTION('',(0.,0.,1.));
#63 = PCURVE('',#31,#64);
#64 = DEFINITIONAL_REPRESENTATION('',(#65),#69);
#65 = LINE('',#66,#67);
#66 = CARTESIAN_POINT('',(-6.283,0.));
#67 = VECTOR('',#68,1.);
#68 = DIRECTION('',(-0.,-1.));
#69 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#70 = PCURVE('',#31,#71);
#71 = DEFINITIONAL_REPRESENTATION('',(#72),#76);
#72 = LINE('',#73,#74);
#73 = CARTESIAN_POINT('',(-0.,0.));
#74 = VECTOR('',#75,1.);
#75 = DIRECTION('',(-0.,-1.));
#76 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#77 = ORIENTED_EDGE('',*,*,#78,.T.);
#78 = EDGE_CURVE('',#56,#79,#81,.T.);
#79 = VERTEX_POINT('',#80);
#80 = CARTESIAN_POINT('',(20.,0.,2.7));
#81 = SEAM_CURVE('',#82,(#86,#93),.PCURVE_S1.);
#82 = LINE('',#83,#84);
#83 = CARTESIAN_POINT('',(20.,0.,0.));
#84 = VECTOR('',#85,1.);
#85 = DIRECTION('',(0.,0.,1.));
#86 = PCURVE('',#31,#87);
#87 = DEFINITIONAL_REPRESENTATION('',(#88),#92);
#88 = LINE('',#89,#90);
#89 = CARTESIAN_POINT('',(-6.283,0.));
#90 = VECTOR('',#91,1.);
#91 = DIRECTION('',(-0.,-1.));
#92 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#93 = PCURVE('',#94,#99);
#94 = CYLINDRICAL_SURFACE('',#95,4.);
#95 = AXIS2_PLACEMENT_3D('',#96,#97,#98);
#96 = CARTESIAN_POINT('',(16.,0.,3.));
#97 = DIRECTION('',(0.,0.,-1.));
#98 = DIRECTION('',(-1.,0.,0.));
#99 = DEFINITIONAL_REPRESENTATION('',(#100),#104);
#100 = LINE('',#101,#102);
#101 = CARTESIAN_POINT('',(3.142,3.));
#102 = VECTOR('',#103,1.);
#103 = DIRECTION('',(0.,-1.));
#104 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#105 = ORIENTED_EDGE('',*,*,#106,.T.);
#106 = EDGE_CURVE('',#79,#107,#109,.T.);
#107 = VERTEX_POINT('',#108);
#108 = CARTESIAN_POINT('',(0.,20.,2.7));
#109 = SURFACE_CURVE('',#110,(#115,#122),.PCURVE_S1.);
#110 = CIRCLE('',#111,20.);
#111 = AXIS2_PLACEMENT_3D('',#112,#113,#114);
#112 = CARTESIAN_POINT('',(0.,0.,2.7));
#113 = DIRECTION('',(0.,0.,1.));
#114 = DIRECTION('',(1.,0.,-0.));
#115 = PCURVE('',#31,#116);
#116 = DEFINITIONAL_REPRESENTATION('',(#117),#121);
#117 = LINE('',#118,#119);
#118 = CARTESIAN_POINT('',(-0.,-2.7));
#119 = VECTOR('',#120,1.);
#120 = DIRECTION('',(-1.,0.));
#121 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#122 = PCURVE('',#123,#128);
#123 = CONICAL_SURFACE('',#124,20.,0.785);
#124 = AXIS2_PLACEMENT_3D('',#125,#126,#127);
#125 = CARTESIAN_POINT('',(0.,0.,2.7));
#126 = DIRECTION('',(-0.,-0.,-1.));
#127 = DIRECTION('',(1.,0.,0.));
#128 = DEFINITIONAL_REPRESENTATION('',(#129),#133);
#129 = LINE('',#130,#131);
#130 = CARTESIAN_POINT('',(-0.,-0.));
#131 = VECTOR('',#132,1.);
#132 = DIRECTION('',(-1.,-0.));
#133 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#134 = ORIENTED_EDGE('',*,*,#135,.T.);
#135 = EDGE_CURVE('',#107,#136,#138,.T.);
#136 = VERTEX_POINT('',#137);
#137 = CARTESIAN_POINT('',(-20.,0.,2.7));
#138 = SURFACE_CURVE('',#139,(#144,#151),.PCURVE_S1.);
#139 = CIRCLE('',#140,20.);
#140 = AXIS2_PLACEMENT_3D('',#141,#142,#143);
#141 = CARTESIAN_POINT('',(0.,0.,2.7));
#142 = DIRECTION('',(0.,0.,1.));
#143 = DIRECTION('',(1.,0.,-0.));
#144 = PCURVE('',#31,#145);
#145 = DEFINITIONAL_REPRESENTATION('',(#146),#150);
#146 = LINE('',#147,#148);
#147 = CARTESIAN_POINT('',(-0.,-2.7));
#148 = VECTOR('',#149,1.);
#149 = DIRECTION('',(-1.,0.));
#150 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#151 = PCURVE('',#152,#157);
#152 = CONICAL_SURFACE('',#153,20.,0.785);
#153 = AXIS2_PLACEMENT_3D('',#154,#155,#156);
#154 = CARTESIAN_POINT('',(0.,0.,2.7));
#155 = DIRECTION('',(-0.,-0.,-1.));
#156 = DIRECTION('',(1.,0.,0.));
#157 = DEFINITIONAL_REPRESENTATION('',(#158),#162);
#158 = LINE('',#159,#160);
#159 = CARTESIAN_POINT('',(-0.,-0.));
#160 = VECTOR('',#161,1.);
#161 = DIRECTION('',(-1.,-0.));
#162 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#163 = ORIENTED_EDGE('',*,*,#164,.T.);
#164 = EDGE_CURVE('',#136,#165,#167,.T.);
#165 = VERTEX_POINT('',#166);
#166 = CARTESIAN_POINT('',(0.,-20.,2.7));
#167 = SURFACE_CURVE('',#168,(#173,#180),.PCURVE_S1.);
#168 = CIRCLE('',#169,20.);
#169 = AXIS2_PLACEMENT_3D('',#170,#171,#172);
#170 = CARTESIAN_POINT('',(0.,0.,2.7));
#171 = DIRECTION('',(0.,0.,1.));
#172 = DIRECTION('',(1.,0.,-0.));
#173 = PCURVE('',#31,#174);
#174 = DEFINITIONAL_REPRESENTATION('',(#175),#179);
#175 = LINE('',#176,#177);
#176 = CARTESIAN_POINT('',(-0.,-2.7));
#177 = VECTOR('',#178,1.);
#178 = DIRECTION('',(-1.,0.));
#179 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#180 = PCURVE('',#181,#186);
#181 = CONICAL_SURFACE('',#182,20.,0.785);
#182 = AXIS2_PLACEMENT_3D('',#183,#184,#185);
#183 = CARTESIAN_POINT('',(0.,0.,2.7));
#184 = DIRECTION('',(-0.,-0.,-1.));
#185 = DIRECTION('',(1.,0.,0.));
#186 = DEFINITIONAL_REPRESENTATION('',(#187),#191);
#187 = LINE('',#188,#189);
#188 = CARTESIAN_POINT('',(-0.,-0.));
#189 = VECTOR('',#190,1.);
#190 = DIRECTION('',(-1.,-0.));
#191 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#192 = ORIENTED_EDGE('',*,*,#193,.T.);
#193 = EDGE_CURVE('',#165,#79,#194,.T.);
#194 = SURFACE_CURVE('',#195,(#200,#207),.PCURVE_S1.);
#195 = CIRCLE('',#196,20.);
#196 = AXIS2_PLACEMENT_3D('',#197,#198,#199);
#197 = CARTESIAN_POINT('',(0.,0.,2.7));
#198 = DIRECTION('',(0.,0.,1.));
#199 = DIRECTION('',(1.,0.,-0.));
#200 = PCURVE('',#31,#201);
#201 = DEFINITIONAL_REPRESENTATION('',(#202),#206);
#202 = LINE('',#203,#204);
#203 = CARTESIAN_POINT('',(-0.,-2.7));
#204 = VECTOR('',#205,1.);
#205 = DIRECTION('',(-1.,0.));
#206 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#207 = PCURVE('',#208,#213);
#208 = CONICAL_SURFACE('',#209,20.,0.785);
#209 = AXIS2_PLACEMENT_3D('',#210,#211,#212);
#210 = CARTESIAN_POINT('',(0.,0.,2.7));
#211 = DIRECTION('',(-0.,-0.,-1.));
#212 = DIRECTION('',(1.,0.,0.));
#213 = DEFINITIONAL_REPRESENTATION('',(#214),#218);
#214 = LINE('',#215,#216);
#215 = CARTESIAN_POINT('',(-0.,-0.));
#216 = VECTOR('',#217,1.);
#217 = DIRECTION('',(-1.,-0.));
#218 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#219 = ORIENTED_EDGE('',*,*,#78,.F.);
#220 = ORIENTED_EDGE('',*,*,#55,.F.);
