STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:28',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 25
Bounding box: 30 x 15 x 8 mm (x, y, z)
Volume: 2500.5 mm3; surface area: 1963.7 mm2
Topology: 1 solids, 1 shells, 31 faces, 84 edges, 56 vertices
Faces by surface type: plane 27, cylinder 4
Entity records: 2056 total; most frequent: CARTESIAN_POINT 388, DIRECTION 296, LINE 212, VECTOR 212, ORIENTED_EDGE 168, PCURVE 168, DEFINITIONAL_REPRESENTATION 168, EDGE_CURVE 84
