One B-rep face of a CAD part: STEP entity #1781.
In plain terms, this planar face has unit normal (0, -1, 0).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#44 = PLANE('',#45);
#45 = AXIS2_PLACEMENT_3D('',#46,#47,#48);
#46 = CARTESIAN_POINT('',(-90.,-25.,5.));
#47 = DIRECTION('',(0.,0.,1.));
#48 = DIRECTION('',(1.,0.,0.));
#184 = CYLINDRICAL_SURFACE('',#185,5.);
#185 = AXIS2_PLACEMENT_3D('',#186,#187,#188);
#186 = CARTESIAN_POINT('',(-85.,-20.,-5.));
#187 = DIRECTION('',(0.,0.,1.));
#188 = DIRECTION('',(-1.,-0.,0.));
#212 = PLANE('',#213);
#213 = AXIS2_PLACEMENT_3D('',#214,#215,#216);
#214 = CARTESIAN_POINT('',(-90.,-25.,-5.));
#215 = DIRECTION('',(0.,0.,1.));
#216 = DIRECTION('',(1.,0.,0.));
#441 = VERTEX_POINT('',#442);
#442 = CARTESIAN_POINT('',(-85.,-25.,5.));
#464 = EDGE_CURVE('',#441,#465,#467,.T.);
#465 = VERTEX_POINT('',#466);
#466 = CARTESIAN_POINT('',(85.,-25.,5.));
#467 = SURFACE_CURVE('',#468,(#472,#479),.PCURVE_S1.);
#468 = LINE('',#469,#470);
#469 = CARTESIAN_POINT('',(-90.,-25.,5.));
#470 = VECTOR('',#471,1.);
#471 = DIRECTION('',(1.,0.,0.));
#472 = PCURVE('',#44,#473);
#473 = DEFINITIONAL_REPRESENTATION('',(#474),#478);
#474 = LINE('',#475,#476);
#475 = CARTESIAN_POINT('',(0.,0.));
#476 = VECTOR('',#477,1.);
#477 = DIRECTION('',(1.,0.));
#478 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#479 = PCURVE('',#480,#485);
#480 = PLANE('',#481);
#481 = AXIS2_PLACEMENT_3D('',#482,#483,#484);
#482 = CARTESIAN_POINT('',(-90.,-25.,-5.));
#483 = DIRECTION('',(0.,1.,0.));
#484 = DIRECTION('',(0.,0.,1.));
#485 = DEFINITIONAL_REPRESENTATION('',(#486),#490);
#486 = LINE('',#487,#488);
#487 = CARTESIAN_POINT('',(10.,0.));
#488 = VECTOR('',#489,1.);
#489 = DIRECTION('',(0.,1.));
#490 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#513 = CYLINDRICAL_SURFACE('',#514,5.);
#514 = AXIS2_PLACEMENT_3D('',#515,#516,#517);
#515 = CARTESIAN_POINT('',(85.,-20.,-5.));
#516 = DIRECTION('',(0.,0.,1.));
#517 = DIRECTION('',(1.,0.,-0.));
#1214 = VERTEX_POINT('',#1215);
#1215 = CARTESIAN_POINT('',(-85.,-25.,-5.));
#1237 = EDGE_CURVE('',#1214,#441,#1238,.T.);
#1238 = SURFACE_CURVE('',#1239,(#1243,#1250),.PCURVE_S1.);
#1239 = LINE('',#1240,#1241);
#1240 = CARTESIAN_POINT('',(-85.,-25.,-5.));
#1241 = VECTOR('',#1242,1.);
#1242 = DIRECTION('',(0.,0.,1.));
#1243 = PCURVE('',#184,#1244);
#1244 = DEFINITIONAL_REPRESENTATION('',(#1245),#1249);
#1245 = LINE('',#1246,#1247);
#1246 = CARTESIAN_POINT('',(1.571,0.));
#1247 = VECTOR('',#1248,1.);
#1248 = DIRECTION('',(0.,1.));
#1249 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1250 = PCURVE('',#480,#1251);
#1251 = DEFINITIONAL_REPRESENTATION('',(#1252),#1256);
#1252 = LINE('',#1253,#1254);
#1253 = CARTESIAN_POINT('',(0.,5.));
#1254 = VECTOR('',#1255,1.);
#1255 = DIRECTION('',(1.,0.));
#1256 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1266 = EDGE_CURVE('',#1214,#1267,#1269,.T.);
#1267 = VERTEX_POINT('',#1268);
#1268 = CARTESIAN_POINT('',(85.,-25.,-5.));
#1269 = SURFACE_CURVE('',#1270,(#1274,#1281),.PCURVE_S1.);
#1270 = LINE('',#1271,#1272);
#1271 = CARTESIAN_POINT('',(-90.,-25.,-5.));
#1272 = VECTOR('',#1273,1.);
#1273 = DIRECTION('',(1.,0.,0.));
#1274 = PCURVE('',#212,#1275);
#1275 = DEFINITIONAL_REPRESENTATION('',(#1276),#1280);
#1276 = LINE('',#1277,#1278);
#1277 = CARTESIAN_POINT('',(0.,0.));
#1278 = VECTOR('',#1279,1.);
#1279 = DIRECTION('',(1.,0.));
#1280 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1281 = PCURVE('',#480,#1282);
#1282 = DEFINITIONAL_REPRESENTATION('',(#1283),#1287);
#1283 = LINE('',#1284,#1285);
#1284 = CARTESIAN_POINT('',(0.,0.));
#1285 = VECTOR('',#1286,1.);
#1286 = DIRECTION('',(0.,1.));
#1287 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1781 = ADVANCED_FACE('',(#1782),#480,.F.);
#1782 = FACE_BOUND('',#1783,.F.);
#1783 = EDGE_LOOP('',(#1784,#1785,#1786,#1787));
#1784 = ORIENTED_EDGE('',*,*,#1266,.F.);
#1785 = ORIENTED_EDGE('',*,*,#1237,.T.);
#1786 = ORIENTED_EDGE('',*,*,#464,.T.);
#1787 = ORIENTED_EDGE('',*,*,#1788,.F.);
#1788 = EDGE_CURVE('',#1267,#465,#1789,.T.);
#1789 = SURFACE_CURVE('',#1790,(#1794,#1801),.PCURVE_S1.);
#1790 = LINE('',#1791,#1792);
#1791 = CARTESIAN_POINT('',(85.,-25.,-5.));
#1792 = VECTOR('',#1793,1.);
#1793 = DIRECTION('',(0.,0.,1.));
#1794 = PCURVE('',#480,#1795);
#1795 = DEFINITIONAL_REPRESENTATION('',(#1796),#1800);
#1796 = LINE('',#1797,#1798);
#1797 = CARTESIAN_POINT('',(0.,175.));
#1798 = VECTOR('',#1799,1.);
#1799 = DIRECTION('',(1.,0.));
#1800 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1801 = PCURVE('',#513,#1802);
#1802 = DEFINITIONAL_REPRESENTATION('',(#1803),#1807);
#1803 = LINE('',#1804,#1805);
#1804 = CARTESIAN_POINT('',(-1.571,0.));
#1805 = VECTOR('',#1806,1.);
#1806 = DIRECTION('',(-0.,1.));
#1807 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
