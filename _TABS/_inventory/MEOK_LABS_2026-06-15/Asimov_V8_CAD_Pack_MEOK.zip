STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:24',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (3): Open CASCADE STEP translator 7.8 9; Open CASCADE STEP translator 7.8 9.1; Open CASCADE STEP translator 7.8 9.2
Assembly tree (2 placements, depth 2):
  Open CASCADE STEP translator 7.8 9
    Open CASCADE STEP translator 7.8 9.1
    Open CASCADE STEP translator 7.8 9.2
Bounding box: 200 x 80 x 23 mm (x, y, z)
Volume: 135252.4 mm3; surface area: 47455 mm2
Topology: 2 solids, 2 shells, 52 faces, 127 edges, 80 vertices
Faces by surface type: plane 29, cylinder 19, cone 4
Full cylindrical faces by diameter (mm): 3.4 x6, 6.5 x6, 8.2 x2, 30 x1
Entity records: 3235 total; most frequent: CARTESIAN_POINT 562, DIRECTION 508, LINE 261, VECTOR 261, ORIENTED_EDGE 254, PCURVE 254, DEFINITIONAL_REPRESENTATION 254, EDGE_CURVE 127
