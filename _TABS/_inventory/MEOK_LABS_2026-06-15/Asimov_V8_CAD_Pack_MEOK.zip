One B-rep face of a CAD part: STEP entity #202.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#24 = VERTEX_POINT('',#25);
#25 = CARTESIAN_POINT('',(25.,0.,4.));
#32 = CYLINDRICAL_SURFACE('',#33,25.);
#33 = AXIS2_PLACEMENT_3D('',#34,#35,#36);
#34 = CARTESIAN_POINT('',(0.,0.,0.));
#35 = DIRECTION('',(-0.,-0.,-1.));
#36 = DIRECTION('',(1.,0.,0.));
#51 = EDGE_CURVE('',#24,#24,#52,.T.);
#52 = SURFACE_CURVE('',#53,(#58,#65),.PCURVE_S1.);
#53 = CIRCLE('',#54,25.);
#54 = AXIS2_PLACEMENT_3D('',#55,#56,#57);
#55 = CARTESIAN_POINT('',(0.,0.,4.));
#56 = DIRECTION('',(0.,0.,1.));
#57 = DIRECTION('',(1.,0.,0.));
#58 = PCURVE('',#32,#59);
#59 = DEFINITIONAL_REPRESENTATION('',(#60),#64);
#60 = LINE('',#61,#62);
#61 = CARTESIAN_POINT('',(-0.,-4.));
#62 = VECTOR('',#63,1.);
#63 = DIRECTION('',(-1.,0.));
#64 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#65 = PCURVE('',#66,#71);
#66 = PLANE('',#67);
#67 = AXIS2_PLACEMENT_3D('',#68,#69,#70);
#68 = CARTESIAN_POINT('',(0.,0.,4.));
#69 = DIRECTION('',(0.,0.,1.));
#70 = DIRECTION('',(1.,0.,-0.));
#71 = DEFINITIONAL_REPRESENTATION('',(#72),#76);
#72 = CIRCLE('',#73,25.);
#73 = AXIS2_PLACEMENT_2D('',#74,#75);
#74 = CARTESIAN_POINT('',(0.,0.));
#75 = DIRECTION('',(1.,0.));
#76 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#129 = CYLINDRICAL_SURFACE('',#130,1.1);
#130 = AXIS2_PLACEMENT_3D('',#131,#132,#133);
#131 = CARTESIAN_POINT('',(0.,-22.,0.));
#132 = DIRECTION('',(0.,0.,1.));
#133 = DIRECTION('',(-1.,0.,0.));
#160 = CYLINDRICAL_SURFACE('',#161,1.1);
#161 = AXIS2_PLACEMENT_3D('',#162,#163,#164);
#162 = CARTESIAN_POINT('',(0.,22.,0.));
#163 = DIRECTION('',(0.,0.,1.));
#164 = DIRECTION('',(-1.,0.,0.));
#191 = CYLINDRICAL_SURFACE('',#192,19.);
#192 = AXIS2_PLACEMENT_3D('',#193,#194,#195);
#193 = CARTESIAN_POINT('',(0.,0.,0.));
#194 = DIRECTION('',(-0.,-0.,-1.));
#195 = DIRECTION('',(1.,0.,0.));
#202 = ADVANCED_FACE('',(#203,#206,#232,#258),#66,.T.);
#203 = FACE_BOUND('',#204,.T.);
#204 = EDGE_LOOP('',(#205));
#205 = ORIENTED_EDGE('',*,*,#51,.T.);
#206 = FACE_BOUND('',#207,.T.);
#207 = EDGE_LOOP('',(#208));
#208 = ORIENTED_EDGE('',*,*,#209,.F.);
#209 = EDGE_CURVE('',#210,#210,#212,.T.);
#210 = VERTEX_POINT('',#211);
#211 = CARTESIAN_POINT('',(-1.1,-22.,4.));
#212 = SURFACE_CURVE('',#213,(#218,#225),.PCURVE_S1.);
#213 = CIRCLE('',#214,1.1);
#214 = AXIS2_PLACEMENT_3D('',#215,#216,#217);
#215 = CARTESIAN_POINT('',(0.,-22.,4.));
#216 = DIRECTION('',(0.,0.,1.));
#217 = DIRECTION('',(-1.,0.,0.));
#218 = PCURVE('',#66,#219);
#219 = DEFINITIONAL_REPRESENTATION('',(#220),#224);
#220 = CIRCLE('',#221,1.1);
#221 = AXIS2_PLACEMENT_2D('',#222,#223);
#222 = CARTESIAN_POINT('',(0.,-22.));
#223 = DIRECTION('',(-1.,0.));
#224 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#225 = PCURVE('',#129,#226);
#226 = DEFINITIONAL_REPRESENTATION('',(#227),#231);
#227 = LINE('',#228,#229);
#228 = CARTESIAN_POINT('',(0.,4.));
#229 = VECTOR('',#230,1.);
#230 = DIRECTION('',(1.,0.));
#231 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#232 = FACE_BOUND('',#233,.T.);
#233 = EDGE_LOOP('',(#234));
#234 = ORIENTED_EDGE('',*,*,#235,.F.);
#235 = EDGE_CURVE('',#236,#236,#238,.T.);
#236 = VERTEX_POINT('',#237);
#237 = CARTESIAN_POINT('',(-1.1,22.,4.));
#238 = SURFACE_CURVE('',#239,(#244,#251),.PCURVE_S1.);
#239 = CIRCLE('',#240,1.1);
#240 = AXIS2_PLACEMENT_3D('',#241,#242,#243);
#241 = CARTESIAN_POINT('',(0.,22.,4.));
#242 = DIRECTION('',(0.,0.,1.));
#243 = DIRECTION('',(-1.,0.,0.));
#244 = PCURVE('',#66,#245);
#245 = DEFINITIONAL_REPRESENTATION('',(#246),#250);
#246 = CIRCLE('',#247,1.1);
#247 = AXIS2_PLACEMENT_2D('',#248,#249);
#248 = CARTESIAN_POINT('',(0.,22.));
#249 = DIRECTION('',(-1.,0.));
#250 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#251 = PCURVE('',#160,#252);
#252 = DEFINITIONAL_REPRESENTATION('',(#253),#257);
#253 = LINE('',#254,#255);
#254 = CARTESIAN_POINT('',(0.,4.));
#255 = VECTOR('',#256,1.);
#256 = DIRECTION('',(1.,0.));
#257 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#258 = FACE_BOUND('',#259,.T.);
#259 = EDGE_LOOP('',(#260));
#260 = ORIENTED_EDGE('',*,*,#261,.F.);
#261 = EDGE_CURVE('',#262,#262,#264,.T.);
#262 = VERTEX_POINT('',#263);
#263 = CARTESIAN_POINT('',(19.,0.,4.));
#264 = SURFACE_CURVE('',#265,(#270,#277),.PCURVE_S1.);
#265 = CIRCLE('',#266,19.);
#266 = AXIS2_PLACEMENT_3D('',#267,#268,#269);
#267 = CARTESIAN_POINT('',(0.,0.,4.));
#268 = DIRECTION('',(0.,0.,1.));
#269 = DIRECTION('',(1.,0.,0.));
#270 = PCURVE('',#66,#271);
#271 = DEFINITIONAL_REPRESENTATION('',(#272),#276);
#272 = CIRCLE('',#273,19.);
#273 = AXIS2_PLACEMENT_2D('',#274,#275);
#274 = CARTESIAN_POINT('',(0.,0.));
#275 = DIRECTION('',(1.,0.));
#276 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#277 = PCURVE('',#191,#278);
#278 = DEFINITIONAL_REPRESENTATION('',(#279),#283);
#279 = LINE('',#280,#281);
#280 = CARTESIAN_POINT('',(-0.,-4.));
#281 = VECTOR('',#282,1.);
#282 = DIRECTION('',(-1.,0.));
#283 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
