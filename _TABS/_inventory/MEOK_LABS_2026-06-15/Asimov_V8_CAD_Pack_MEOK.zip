STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:27',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 19
Bounding box: 15 x 12 x 8 mm (x, y, z)
Volume: 1288.3 mm3; surface area: 880.4 mm2
Topology: 1 solids, 1 shells, 27 faces, 66 edges, 40 vertices
Faces by surface type: plane 17, cylinder 6, cone 4
Full cylindrical faces by diameter (mm): 2.2 x2
Entity records: 1662 total; most frequent: CARTESIAN_POINT 318, DIRECTION 252, LINE 146, VECTOR 146, ORIENTED_EDGE 132, PCURVE 132, DEFINITIONAL_REPRESENTATION 132, EDGE_CURVE 66
