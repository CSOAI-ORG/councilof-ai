STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:23',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 8
Bounding box: 80 x 70 x 50 mm (x, y, z)
Volume: 137936.3 mm3; surface area: 35860.5 mm2
Topology: 1 solids, 1 shells, 48 faces, 139 edges, 90 vertices
Faces by surface type: plane 31, cylinder 13, cone 4
Full cylindrical faces by diameter (mm): 5.5 x4, 8.2 x1
Entity records: 3398 total; most frequent: CARTESIAN_POINT 796, DIRECTION 441, ORIENTED_EDGE 278, PCURVE 278, DEFINITIONAL_REPRESENTATION 278, LINE 233, VECTOR 233, EDGE_CURVE 139
