STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:23',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 5
Bounding box: 120 x 15 x 8 mm (x, y, z)
Volume: 12643.5 mm3; surface area: 6297.1 mm2
Topology: 1 solids, 1 shells, 25 faces, 58 edges, 36 vertices
Faces by surface type: plane 15, cylinder 6, cone 4
Full cylindrical faces by diameter (mm): 4.2 x2
Entity records: 1490 total; most frequent: CARTESIAN_POINT 312, DIRECTION 216, LINE 130, VECTOR 130, ORIENTED_EDGE 116, PCURVE 116, DEFINITIONAL_REPRESENTATION 116, EDGE_CURVE 58
