STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:24',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 8
Bounding box: 50 x 20 x 30 mm (x, y, z)
Volume: 27346.2 mm3; surface area: 6859 mm2
Topology: 1 solids, 1 shells, 40 faces, 112 edges, 72 vertices
Faces by surface type: plane 23, cylinder 13, cone 4
Full cylindrical faces by diameter (mm): 4.2 x3
Entity records: 3162 total; most frequent: CARTESIAN_POINT 1029, DIRECTION 369, ORIENTED_EDGE 224, PCURVE 224, DEFINITIONAL_REPRESENTATION 224, LINE 201, VECTOR 201, EDGE_CURVE 112
