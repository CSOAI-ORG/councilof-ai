STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:50',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 5
Bounding box: 85 x 30 x 8 mm (x, y, z)
Volume: 19999.6 mm3; surface area: 7126.8 mm2
Topology: 1 solids, 1 shells, 14 faces, 36 edges, 24 vertices
Faces by surface type: cylinder 8, plane 6
Full cylindrical faces by diameter (mm): 3.4 x4
Entity records: 966 total; most frequent: CARTESIAN_POINT 219, DIRECTION 142, LINE 76, VECTOR 76, ORIENTED_EDGE 72, PCURVE 72, DEFINITIONAL_REPRESENTATION 72, EDGE_CURVE 36
