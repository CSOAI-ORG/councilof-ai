STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:50',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 6
Bounding box: 50 x 50 x 15 mm (x, y, z)
Volume: 26047.3 mm3; surface area: 6866.6 mm2
Topology: 1 solids, 1 shells, 10 faces, 20 edges, 13 vertices
Faces by surface type: plane 7, cylinder 2, torus 1
Full cylindrical faces by diameter (mm): 10 x1, 50 x1
Entity records: 540 total; most frequent: CARTESIAN_POINT 98, DIRECTION 84, LINE 48, VECTOR 48, ORIENTED_EDGE 40, PCURVE 40, DEFINITIONAL_REPRESENTATION 40, EDGE_CURVE 20
