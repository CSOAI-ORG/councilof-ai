STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:26',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 14
Bounding box: 38 x 26 x 14 mm (x, y, z)
Volume: 6989.4 mm3; surface area: 4797.9 mm2
Topology: 1 solids, 1 shells, 29 faces, 78 edges, 52 vertices
Faces by surface type: plane 21, cylinder 8
Full cylindrical faces by diameter (mm): 3.4 x2
Entity records: 1928 total; most frequent: CARTESIAN_POINT 364, DIRECTION 282, LINE 178, VECTOR 178, ORIENTED_EDGE 156, PCURVE 156, DEFINITIONAL_REPRESENTATION 156, EDGE_CURVE 78
