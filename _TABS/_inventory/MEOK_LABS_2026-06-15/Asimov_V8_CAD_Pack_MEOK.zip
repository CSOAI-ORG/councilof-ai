One B-rep face of a CAD part: STEP entity #1577.
In plain terms, this planar face has unit normal (0, -1, 0).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#70 = PLANE('',#71);
#71 = AXIS2_PLACEMENT_3D('',#72,#73,#74);
#72 = CARTESIAN_POINT('',(-110.,-30.,6.));
#73 = DIRECTION('',(0.,0.,1.));
#74 = DIRECTION('',(1.,0.,0.));
#98 = CYLINDRICAL_SURFACE('',#99,6.);
#99 = AXIS2_PLACEMENT_3D('',#100,#101,#102);
#100 = CARTESIAN_POINT('',(-104.,-24.,-6.));
#101 = DIRECTION('',(0.,0.,1.));
#102 = DIRECTION('',(-1.,-0.,0.));
#126 = PLANE('',#127);
#127 = AXIS2_PLACEMENT_3D('',#128,#129,#130);
#128 = CARTESIAN_POINT('',(-110.,-30.,-6.));
#129 = DIRECTION('',(0.,0.,1.));
#130 = DIRECTION('',(1.,0.,0.));
#253 = VERTEX_POINT('',#254);
#254 = CARTESIAN_POINT('',(-104.,-30.,6.));
#276 = EDGE_CURVE('',#253,#277,#279,.T.);
#277 = VERTEX_POINT('',#278);
#278 = CARTESIAN_POINT('',(104.,-30.,6.));
#279 = SURFACE_CURVE('',#280,(#284,#291),.PCURVE_S1.);
#280 = LINE('',#281,#282);
#281 = CARTESIAN_POINT('',(-110.,-30.,6.));
#282 = VECTOR('',#283,1.);
#283 = DIRECTION('',(1.,0.,0.));
#284 = PCURVE('',#70,#285);
#285 = DEFINITIONAL_REPRESENTATION('',(#286),#290);
#286 = LINE('',#287,#288);
#287 = CARTESIAN_POINT('',(0.,0.));
#288 = VECTOR('',#289,1.);
#289 = DIRECTION('',(1.,0.));
#290 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#291 = PCURVE('',#292,#297);
#292 = PLANE('',#293);
#293 = AXIS2_PLACEMENT_3D('',#294,#295,#296);
#294 = CARTESIAN_POINT('',(-110.,-30.,-6.));
#295 = DIRECTION('',(0.,1.,0.));
#296 = DIRECTION('',(0.,0.,1.));
#297 = DEFINITIONAL_REPRESENTATION('',(#298),#302);
#298 = LINE('',#299,#300);
#299 = CARTESIAN_POINT('',(12.,0.));
#300 = VECTOR('',#301,1.);
#301 = DIRECTION('',(0.,1.));
#302 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#325 = CYLINDRICAL_SURFACE('',#326,6.);
#326 = AXIS2_PLACEMENT_3D('',#327,#328,#329);
#327 = CARTESIAN_POINT('',(104.,-24.,-6.));
#328 = DIRECTION('',(0.,0.,1.));
#329 = DIRECTION('',(1.,0.,-0.));
#695 = VERTEX_POINT('',#696);
#696 = CARTESIAN_POINT('',(-104.,-30.,-6.));
#718 = EDGE_CURVE('',#695,#253,#719,.T.);
#719 = SURFACE_CURVE('',#720,(#724,#731),.PCURVE_S1.);
#720 = LINE('',#721,#722);
#721 = CARTESIAN_POINT('',(-104.,-30.,-6.));
#722 = VECTOR('',#723,1.);
#723 = DIRECTION('',(0.,0.,1.));
#724 = PCURVE('',#98,#725);
#725 = DEFINITIONAL_REPRESENTATION('',(#726),#730);
#726 = LINE('',#727,#728);
#727 = CARTESIAN_POINT('',(1.571,0.));
#728 = VECTOR('',#729,1.);
#729 = DIRECTION('',(0.,1.));
#730 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#731 = PCURVE('',#292,#732);
#732 = DEFINITIONAL_REPRESENTATION('',(#733),#737);
#733 = LINE('',#734,#735);
#734 = CARTESIAN_POINT('',(0.,6.));
#735 = VECTOR('',#736,1.);
#736 = DIRECTION('',(1.,0.));
#737 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#858 = EDGE_CURVE('',#695,#859,#861,.T.);
#859 = VERTEX_POINT('',#860);
#860 = CARTESIAN_POINT('',(104.,-30.,-6.));
#861 = SURFACE_CURVE('',#862,(#866,#873),.PCURVE_S1.);
#862 = LINE('',#863,#864);
#863 = CARTESIAN_POINT('',(-110.,-30.,-6.));
#864 = VECTOR('',#865,1.);
#865 = DIRECTION('',(1.,0.,0.));
#866 = PCURVE('',#126,#867);
#867 = DEFINITIONAL_REPRESENTATION('',(#868),#872);
#868 = LINE('',#869,#870);
#869 = CARTESIAN_POINT('',(0.,0.));
#870 = VECTOR('',#871,1.);
#871 = DIRECTION('',(1.,0.));
#872 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#873 = PCURVE('',#292,#874);
#874 = DEFINITIONAL_REPRESENTATION('',(#875),#879);
#875 = LINE('',#876,#877);
#876 = CARTESIAN_POINT('',(0.,0.));
#877 = VECTOR('',#878,1.);
#878 = DIRECTION('',(0.,1.));
#879 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1577 = ADVANCED_FACE('',(#1578),#292,.F.);
#1578 = FACE_BOUND('',#1579,.F.);
#1579 = EDGE_LOOP('',(#1580,#1581,#1582,#1583));
#1580 = ORIENTED_EDGE('',*,*,#858,.F.);
#1581 = ORIENTED_EDGE('',*,*,#718,.T.);
#1582 = ORIENTED_EDGE('',*,*,#276,.T.);
#1583 = ORIENTED_EDGE('',*,*,#1584,.F.);
#1584 = EDGE_CURVE('',#859,#277,#1585,.T.);
#1585 = SURFACE_CURVE('',#1586,(#1590,#1597),.PCURVE_S1.);
#1586 = LINE('',#1587,#1588);
#1587 = CARTESIAN_POINT('',(104.,-30.,-6.));
#1588 = VECTOR('',#1589,1.);
#1589 = DIRECTION('',(0.,0.,1.));
#1590 = PCURVE('',#292,#1591);
#1591 = DEFINITIONAL_REPRESENTATION('',(#1592),#1596);
#1592 = LINE('',#1593,#1594);
#1593 = CARTESIAN_POINT('',(0.,214.));
#1594 = VECTOR('',#1595,1.);
#1595 = DIRECTION('',(1.,0.));
#1596 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1597 = PCURVE('',#325,#1598);
#1598 = DEFINITIONAL_REPRESENTATION('',(#1599),#1603);
#1599 = LINE('',#1600,#1601);
#1600 = CARTESIAN_POINT('',(-1.571,0.));
#1601 = VECTOR('',#1602,1.);
#1602 = DIRECTION('',(-0.,1.));
#1603 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
