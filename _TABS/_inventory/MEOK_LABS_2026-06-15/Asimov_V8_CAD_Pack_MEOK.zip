STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:50',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 4
Bounding box: 26 x 26 x 10 mm (x, y, z)
Volume: 3332 mm3; surface area: 2480.8 mm2
Topology: 1 solids, 1 shells, 28 faces, 70 edges, 44 vertices
Faces by surface type: plane 14, cylinder 14
Full cylindrical faces by diameter (mm): 2.7 x4, 3.4 x2, 6 x4
Entity records: 1826 total; most frequent: CARTESIAN_POINT 355, DIRECTION 292, ORIENTED_EDGE 140, PCURVE 140, DEFINITIONAL_REPRESENTATION 140, LINE 138, VECTOR 138, EDGE_CURVE 70
