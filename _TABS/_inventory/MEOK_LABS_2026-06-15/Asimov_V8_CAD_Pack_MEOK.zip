STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:24',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 10
Bounding box: 30 x 20 x 8 mm (x, y, z)
Volume: 4193.2 mm3; surface area: 2093.6 mm2
Topology: 1 solids, 1 shells, 20 faces, 46 edges, 28 vertices
Faces by surface type: plane 10, cylinder 6, cone 4
Full cylindrical faces by diameter (mm): 4.2 x1, 8.2 x1
Entity records: 1192 total; most frequent: CARTESIAN_POINT 263, DIRECTION 170, LINE 94, VECTOR 94, ORIENTED_EDGE 92, PCURVE 92, DEFINITIONAL_REPRESENTATION 92, EDGE_CURVE 46
