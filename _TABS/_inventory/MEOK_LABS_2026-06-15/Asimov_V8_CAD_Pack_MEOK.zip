STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:45',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 5
Bounding box: 20 x 8 x 5 mm (x, y, z)
Volume: 735.6 mm3; surface area: 662.2 mm2
Topology: 1 solids, 1 shells, 8 faces, 18 edges, 12 vertices
Faces by surface type: plane 6, cylinder 2
Full cylindrical faces by diameter (mm): 2.2 x1, 3.4 x1
Entity records: 490 total; most frequent: CARTESIAN_POINT 99, DIRECTION 72, LINE 46, VECTOR 46, ORIENTED_EDGE 36, PCURVE 36, DEFINITIONAL_REPRESENTATION 36, EDGE_CURVE 18
