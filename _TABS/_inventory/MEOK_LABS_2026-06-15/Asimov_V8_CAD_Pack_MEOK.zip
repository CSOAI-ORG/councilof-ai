STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:45',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 8
Bounding box: 40 x 40 x 30 mm (x, y, z)
Volume: 10461.5 mm3; surface area: 7671.8 mm2
Topology: 1 solids, 1 shells, 4 faces, 6 edges, 4 vertices
Faces by surface type: cylinder 2, plane 2
Full cylindrical faces by diameter (mm): 34 x1, 40 x1
Entity records: 186 total; most frequent: DIRECTION 32, CARTESIAN_POINT 27, ORIENTED_EDGE 12, PCURVE 12, DEFINITIONAL_REPRESENTATION 12, LINE 10, VECTOR 10, AXIS2_PLACEMENT_3D 9
