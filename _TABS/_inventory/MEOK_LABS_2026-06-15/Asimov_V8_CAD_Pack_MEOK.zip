STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:26:43',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 11
Bounding box: 50 x 50 x 3 mm (x, y, z)
Volume: 6626.6 mm3; surface area: 6092.8 mm2
Topology: 1 solids, 1 shells, 50 faces, 144 edges, 96 vertices
Faces by surface type: cylinder 44, plane 6
Full cylindrical faces by diameter (mm): 2.2 x4, 3 x36
Entity records: 3966 total; most frequent: CARTESIAN_POINT 1035, DIRECTION 546, ORIENTED_EDGE 288, PCURVE 288, DEFINITIONAL_REPRESENTATION 288, LINE 256, VECTOR 256, EDGE_CURVE 144
