STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:03:03',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (4): Open CASCADE STEP translator 7.8 1; Open CASCADE STEP translator 7.8 1.1; Open CASCADE STEP translator 7.8 1.2; Open CASCADE STEP translator 7.8 1.3
Assembly tree (3 placements, depth 2):
  Open CASCADE STEP translator 7.8 1
    Open CASCADE STEP translator 7.8 1.1
    Open CASCADE STEP translator 7.8 1.2
    Open CASCADE STEP translator 7.8 1.3
Bounding box: 222 x 60 x 182 mm (x, y, z)
Volume: 154521.3 mm3; surface area: 43022.9 mm2
Topology: 3 solids, 3 shells, 47 faces, 105 edges, 68 vertices
Faces by surface type: plane 34, cylinder 13
Full cylindrical faces by diameter (mm): 5.5 x4, 10 x4, 32 x1
Entity records: 2762 total; most frequent: CARTESIAN_POINT 470, DIRECTION 439, LINE 259, VECTOR 259, ORIENTED_EDGE 210, PCURVE 210, DEFINITIONAL_REPRESENTATION 210, EDGE_CURVE 105
