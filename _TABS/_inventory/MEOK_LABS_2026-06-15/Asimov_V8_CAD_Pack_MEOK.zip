STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:26:44',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 16
Bounding box: 60 x 50 x 50 mm (x, y, z)
Volume: 84162.3 mm3; surface area: 22710.2 mm2
Topology: 1 solids, 1 shells, 19 faces, 42 edges, 28 vertices
Faces by surface type: plane 13, cylinder 6
Full cylindrical faces by diameter (mm): 3.4 x2
Entity records: 1096 total; most frequent: CARTESIAN_POINT 198, DIRECTION 174, LINE 102, VECTOR 102, ORIENTED_EDGE 84, PCURVE 84, DEFINITIONAL_REPRESENTATION 84, EDGE_CURVE 42
