STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:21',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 4
Bounding box: 60 x 50 x 40 mm (x, y, z)
Volume: 96355.5 mm3; surface area: 18948.2 mm2
Topology: 1 solids, 1 shells, 21 faces, 49 edges, 33 vertices
Faces by surface type: plane 13, cylinder 8
Full cylindrical faces by diameter (mm): 5.5 x2, 10 x2
Entity records: 1274 total; most frequent: CARTESIAN_POINT 226, DIRECTION 203, LINE 115, VECTOR 115, ORIENTED_EDGE 98, PCURVE 98, DEFINITIONAL_REPRESENTATION 98, EDGE_CURVE 49
