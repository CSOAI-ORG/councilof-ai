STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:45',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 3
Bounding box: 25 x 3 x 15 mm (x, y, z)
Volume: 865.6 mm3; surface area: 1090.8 mm2
Topology: 1 solids, 1 shells, 15 faces, 42 edges, 28 vertices
Faces by surface type: plane 13, cylinder 2
Full cylindrical faces by diameter (mm): 2.2 x2
Entity records: 1040 total; most frequent: CARTESIAN_POINT 178, DIRECTION 158, LINE 102, VECTOR 102, ORIENTED_EDGE 84, PCURVE 84, DEFINITIONAL_REPRESENTATION 84, EDGE_CURVE 42
