One B-rep face of a CAD part: STEP entity #4068.
In plain terms, this cylindrical face has radius 5 mm (diameter 10 mm), a full revolution.
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#577 = PLANE('',#578);
#578 = AXIS2_PLACEMENT_3D('',#579,#580,#581);
#579 = CARTESIAN_POINT('',(0.,0.,0.));
#580 = DIRECTION('',(0.,0.,1.));
#581 = DIRECTION('',(1.,0.,-0.));
#2388 = PLANE('',#2389);
#2389 = AXIS2_PLACEMENT_3D('',#2390,#2391,#2392);
#2390 = CARTESIAN_POINT('',(0.,0.,15.)
  );
#2391 = DIRECTION('',(0.,0.,1.));
#2392 = DIRECTION('',(1.,0.,-0.));
#3506 = EDGE_CURVE('',#3507,#3507,#3509,.T.);
#3507 = VERTEX_POINT('',#3508);
#3508 = CARTESIAN_POINT('',(5.,0.,0.));
#3509 = SURFACE_CURVE('',#3510,(#3515,#3522),.PCURVE_S1.);
#3510 = CIRCLE('',#3511,5.);
#3511 = AXIS2_PLACEMENT_3D('',#3512,#3513,#3514);
#3512 = CARTESIAN_POINT('',(0.,0.,0.));
#3513 = DIRECTION('',(0.,0.,1.));
#3514 = DIRECTION('',(1.,0.,-0.));
#3515 = PCURVE('',#577,#3516);
#3516 = DEFINITIONAL_REPRESENTATION('',(#3517),#3521);
#3517 = CIRCLE('',#3518,5.);
#3518 = AXIS2_PLACEMENT_2D('',#3519,#3520);
#3519 = CARTESIAN_POINT('',(0.,0.));
#3520 = DIRECTION('',(1.,0.));
#3521 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#3522 = PCURVE('',#3523,#3528);
#3523 = CYLINDRICAL_SURFACE('',#3524,5.);
#3524 = AXIS2_PLACEMENT_3D('',#3525,#3526,#3527);
#3525 = CARTESIAN_POINT('',(0.,0.,-28.296));
#3526 = DIRECTION('',(-0.,-0.,-1.));
#3527 = DIRECTION('',(1.,0.,0.));
#3528 = DEFINITIONAL_REPRESENTATION('',(#3529),#3533);
#3529 = LINE('',#3530,#3531);
#3530 = CARTESIAN_POINT('',(-0.,-28.296));
#3531 = VECTOR('',#3532,1.);
#3532 = DIRECTION('',(-1.,-0.));
#3533 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#4038 = EDGE_CURVE('',#4039,#4039,#4041,.T.);
#4039 = VERTEX_POINT('',#4040);
#4040 = CARTESIAN_POINT('',(5.,0.,15.));
#4041 = SURFACE_CURVE('',#4042,(#4047,#4058),.PCURVE_S1.);
#4042 = CIRCLE('',#4043,5.);
#4043 = AXIS2_PLACEMENT_3D('',#4044,#4045,#4046);
#4044 = CARTESIAN_POINT('',(0.,0.,15.));
#4045 = DIRECTION('',(0.,0.,-1.));
#4046 = DIRECTION('',(1.,0.,0.));
#4047 = PCURVE('',#2388,#4048);
#4048 = DEFINITIONAL_REPRESENTATION('',(#4049),#4057);
#4049 = ( BOUNDED_CURVE() B_SPLINE_CURVE(2,(#4050,#4051,#4052,#4053,
#4054,#4055,#4056),.UNSPECIFIED.,.T.,.F.) B_SPLINE_CURVE_WITH_KNOTS((1,2
    ,2,2,2,1),(-2.094,0.,2.094,4.189,
6.283,8.378),.UNSPECIFIED.) CURVE() 
GEOMETRIC_REPRESENTATION_ITEM() RATIONAL_B_SPLINE_CURVE((1.,0.5,1.,0.5,
1.,0.5,1.)) REPRESENTATION_ITEM('') );
#4050 = CARTESIAN_POINT('',(5.,0.));
#4051 = CARTESIAN_POINT('',(5.,-8.66));
#4052 = CARTESIAN_POINT('',(-2.5,-4.33));
#4053 = CARTESIAN_POINT('',(-10.,0.));
#4054 = CARTESIAN_POINT('',(-2.5,4.33));
#4055 = CARTESIAN_POINT('',(5.,8.66));
#4056 = CARTESIAN_POINT('',(5.,0.));
#4057 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#4058 = PCURVE('',#3523,#4059);
#4059 = DEFINITIONAL_REPRESENTATION('',(#4060),#4064);
#4060 = LINE('',#4061,#4062);
#4061 = CARTESIAN_POINT('',(-6.283,-43.296));
#4062 = VECTOR('',#4063,1.);
#4063 = DIRECTION('',(1.,-0.));
#4064 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#4068 = ADVANCED_FACE('',(#4069),#3523,.F.);
#4069 = FACE_BOUND('',#4070,.T.);
#4070 = EDGE_LOOP('',(#4071,#4072,#4093,#4094));
#4071 = ORIENTED_EDGE('',*,*,#3506,.F.);
#4072 = ORIENTED_EDGE('',*,*,#4073,.T.);
#4073 = EDGE_CURVE('',#3507,#4039,#4074,.T.);
#4074 = SEAM_CURVE('',#4075,(#4079,#4086),.PCURVE_S1.);
#4075 = LINE('',#4076,#4077);
#4076 = CARTESIAN_POINT('',(5.,0.,-28.296));
#4077 = VECTOR('',#4078,1.);
#4078 = DIRECTION('',(0.,0.,1.));
#4079 = PCURVE('',#3523,#4080);
#4080 = DEFINITIONAL_REPRESENTATION('',(#4081),#4085);
#4081 = LINE('',#4082,#4083);
#4082 = CARTESIAN_POINT('',(-0.,0.));
#4083 = VECTOR('',#4084,1.);
#4084 = DIRECTION('',(-0.,-1.));
#4085 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#4086 = PCURVE('',#3523,#4087);
#4087 = DEFINITIONAL_REPRESENTATION('',(#4088),#4092);
#4088 = LINE('',#4089,#4090);
#4089 = CARTESIAN_POINT('',(-6.283,0.));
#4090 = VECTOR('',#4091,1.);
#4091 = DIRECTION('',(-0.,-1.));
#4092 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#4093 = ORIENTED_EDGE('',*,*,#4038,.F.);
#4094 = ORIENTED_EDGE('',*,*,#4073,.F.);
