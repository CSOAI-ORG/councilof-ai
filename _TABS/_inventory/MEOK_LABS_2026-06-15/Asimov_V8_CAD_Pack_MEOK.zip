One B-rep face of a CAD part: STEP entity #144.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#24 = VERTEX_POINT('',#25);
#25 = CARTESIAN_POINT('',(22.,0.,5.));
#32 = CYLINDRICAL_SURFACE('',#33,22.);
#33 = AXIS2_PLACEMENT_3D('',#34,#35,#36);
#34 = CARTESIAN_POINT('',(0.,0.,0.));
#35 = DIRECTION('',(-0.,-0.,-1.));
#36 = DIRECTION('',(1.,0.,0.));
#51 = EDGE_CURVE('',#24,#24,#52,.T.);
#52 = SURFACE_CURVE('',#53,(#58,#65),.PCURVE_S1.);
#53 = CIRCLE('',#54,22.);
#54 = AXIS2_PLACEMENT_3D('',#55,#56,#57);
#55 = CARTESIAN_POINT('',(0.,0.,5.));
#56 = DIRECTION('',(0.,0.,1.));
#57 = DIRECTION('',(1.,0.,0.));
#58 = PCURVE('',#32,#59);
#59 = DEFINITIONAL_REPRESENTATION('',(#60),#64);
#60 = LINE('',#61,#62);
#61 = CARTESIAN_POINT('',(-0.,-5.));
#62 = VECTOR('',#63,1.);
#63 = DIRECTION('',(-1.,0.));
#64 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#65 = PCURVE('',#66,#71);
#66 = PLANE('',#67);
#67 = AXIS2_PLACEMENT_3D('',#68,#69,#70);
#68 = CARTESIAN_POINT('',(0.,0.,5.));
#69 = DIRECTION('',(0.,0.,1.));
#70 = DIRECTION('',(1.,0.,-0.));
#71 = DEFINITIONAL_REPRESENTATION('',(#72),#76);
#72 = CIRCLE('',#73,22.);
#73 = AXIS2_PLACEMENT_2D('',#74,#75);
#74 = CARTESIAN_POINT('',(0.,0.));
#75 = DIRECTION('',(1.,0.));
#76 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#144 = ADVANCED_FACE('',(#145,#148),#66,.T.);
#145 = FACE_BOUND('',#146,.T.);
#146 = EDGE_LOOP('',(#147));
#147 = ORIENTED_EDGE('',*,*,#51,.T.);
#148 = FACE_BOUND('',#149,.T.);
#149 = EDGE_LOOP('',(#150));
#150 = ORIENTED_EDGE('',*,*,#151,.F.);
#151 = EDGE_CURVE('',#152,#152,#154,.T.);
#152 = VERTEX_POINT('',#153);
#153 = CARTESIAN_POINT('',(18.,0.,5.));
#154 = SURFACE_CURVE('',#155,(#160,#167),.PCURVE_S1.);
#155 = CIRCLE('',#156,18.);
#156 = AXIS2_PLACEMENT_3D('',#157,#158,#159);
#157 = CARTESIAN_POINT('',(0.,0.,5.));
#158 = DIRECTION('',(0.,0.,1.));
#159 = DIRECTION('',(1.,0.,0.));
#160 = PCURVE('',#66,#161);
#161 = DEFINITIONAL_REPRESENTATION('',(#162),#166);
#162 = CIRCLE('',#163,18.);
#163 = AXIS2_PLACEMENT_2D('',#164,#165);
#164 = CARTESIAN_POINT('',(0.,0.));
#165 = DIRECTION('',(1.,0.));
#166 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#167 = PCURVE('',#168,#173);
#168 = CYLINDRICAL_SURFACE('',#169,18.);
#169 = AXIS2_PLACEMENT_3D('',#170,#171,#172);
#170 = CARTESIAN_POINT('',(0.,0.,5.));
#171 = DIRECTION('',(0.,0.,1.));
#172 = DIRECTION('',(1.,0.,0.));
#173 = DEFINITIONAL_REPRESENTATION('',(#174),#178);
#174 = LINE('',#175,#176);
#175 = CARTESIAN_POINT('',(0.,0.));
#176 = VECTOR('',#177,1.);
#177 = DIRECTION('',(1.,0.));
#178 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
