STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:22',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 6
Bounding box: 40 x 40 x 22 mm (x, y, z)
Volume: 28724.9 mm3; surface area: 7613.8 mm2
Topology: 1 solids, 1 shells, 27 faces, 58 edges, 36 vertices
Faces by surface type: plane 13, cylinder 10, cone 4
Full cylindrical faces by diameter (mm): 3.4 x2, 6.5 x2, 16 x1, 24 x1
Entity records: 1501 total; most frequent: CARTESIAN_POINT 272, DIRECTION 235, ORIENTED_EDGE 116, PCURVE 116, DEFINITIONAL_REPRESENTATION 116, LINE 114, VECTOR 114, EDGE_CURVE 58
