One B-rep face of a CAD part: STEP entity #137.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#21 = EDGE_CURVE('',#22,#24,#26,.T.);
#22 = VERTEX_POINT('',#23);
#23 = CARTESIAN_POINT('',(-18.,-10.,2.));
#24 = VERTEX_POINT('',#25);
#25 = CARTESIAN_POINT('',(-18.,10.,2.));
#26 = SURFACE_CURVE('',#27,(#31,#43),.PCURVE_S1.);
#27 = LINE('',#28,#29);
#28 = CARTESIAN_POINT('',(-18.,-12.,2.));
#29 = VECTOR('',#30,1.);
#30 = DIRECTION('',(0.,1.,0.));
#31 = PCURVE('',#32,#37);
#32 = PLANE('',#33);
#33 = AXIS2_PLACEMENT_3D('',#34,#35,#36);
#34 = CARTESIAN_POINT('',(-18.,-12.,-2.));
#35 = DIRECTION('',(1.,0.,0.));
#36 = DIRECTION('',(0.,0.,1.));
#37 = DEFINITIONAL_REPRESENTATION('',(#38),#42);
#38 = LINE('',#39,#40);
#39 = CARTESIAN_POINT('',(4.,0.));
#40 = VECTOR('',#41,1.);
#41 = DIRECTION('',(0.,-1.));
#42 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#43 = PCURVE('',#44,#49);
#44 = PLANE('',#45);
#45 = AXIS2_PLACEMENT_3D('',#46,#47,#48);
#46 = CARTESIAN_POINT('',(-18.,-12.,2.));
#47 = DIRECTION('',(0.,0.,1.));
#48 = DIRECTION('',(1.,0.,0.));
#49 = DEFINITIONAL_REPRESENTATION('',(#50),#54);
#50 = LINE('',#51,#52);
#51 = CARTESIAN_POINT('',(0.,0.));
#52 = VECTOR('',#53,1.);
#53 = DIRECTION('',(0.,1.));
#54 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#72 = CYLINDRICAL_SURFACE('',#73,2.);
#73 = AXIS2_PLACEMENT_3D('',#74,#75,#76);
#74 = CARTESIAN_POINT('',(-16.,-10.,-2.));
#75 = DIRECTION('',(0.,0.,1.));
#76 = DIRECTION('',(-1.,-0.,0.));
#126 = CYLINDRICAL_SURFACE('',#127,2.);
#127 = AXIS2_PLACEMENT_3D('',#128,#129,#130);
#128 = CARTESIAN_POINT('',(-16.,10.,-2.));
#129 = DIRECTION('',(0.,0.,1.));
#130 = DIRECTION('',(-1.,-0.,0.));
#137 = ADVANCED_FACE('',(#138),#44,.T.);
#138 = FACE_BOUND('',#139,.T.);
#139 = EDGE_LOOP('',(#140,#141,#165,#193,#226,#254,#283,#311));
#140 = ORIENTED_EDGE('',*,*,#21,.F.);
#141 = ORIENTED_EDGE('',*,*,#142,.T.);
#142 = EDGE_CURVE('',#22,#143,#145,.T.);
#143 = VERTEX_POINT('',#144);
#144 = CARTESIAN_POINT('',(-16.,-12.,2.));
#145 = SURFACE_CURVE('',#146,(#151,#158),.PCURVE_S1.);
#146 = CIRCLE('',#147,2.);
#147 = AXIS2_PLACEMENT_3D('',#148,#149,#150);
#148 = CARTESIAN_POINT('',(-16.,-10.,2.));
#149 = DIRECTION('',(0.,0.,1.));
#150 = DIRECTION('',(0.,-1.,0.));
#151 = PCURVE('',#44,#152);
#152 = DEFINITIONAL_REPRESENTATION('',(#153),#157);
#153 = CIRCLE('',#154,2.);
#154 = AXIS2_PLACEMENT_2D('',#155,#156);
#155 = CARTESIAN_POINT('',(2.,2.));
#156 = DIRECTION('',(0.,-1.));
#157 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#158 = PCURVE('',#72,#159);
#159 = DEFINITIONAL_REPRESENTATION('',(#160),#164);
#160 = LINE('',#161,#162);
#161 = CARTESIAN_POINT('',(-4.712,4.));
#162 = VECTOR('',#163,1.);
#163 = DIRECTION('',(1.,0.));
#164 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#165 = ORIENTED_EDGE('',*,*,#166,.T.);
#166 = EDGE_CURVE('',#143,#167,#169,.T.);
#167 = VERTEX_POINT('',#168);
#168 = CARTESIAN_POINT('',(16.,-12.,2.));
#169 = SURFACE_CURVE('',#170,(#174,#181),.PCURVE_S1.);
#170 = LINE('',#171,#172);
#171 = CARTESIAN_POINT('',(-18.,-12.,2.));
#172 = VECTOR('',#173,1.);
#173 = DIRECTION('',(1.,0.,0.));
#174 = PCURVE('',#44,#175);
#175 = DEFINITIONAL_REPRESENTATION('',(#176),#180);
#176 = LINE('',#177,#178);
#177 = CARTESIAN_POINT('',(0.,0.));
#178 = VECTOR('',#179,1.);
#179 = DIRECTION('',(1.,0.));
#180 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#181 = PCURVE('',#182,#187);
#182 = PLANE('',#183);
#183 = AXIS2_PLACEMENT_3D('',#184,#185,#186);
#184 = CARTESIAN_POINT('',(-18.,-12.,-2.));
#185 = DIRECTION('',(0.,1.,0.));
#186 = DIRECTION('',(0.,0.,1.));
#187 = DEFINITIONAL_REPRESENTATION('',(#188),#192);
#188 = LINE('',#189,#190);
#189 = CARTESIAN_POINT('',(4.,0.));
#190 = VECTOR('',#191,1.);
#191 = DIRECTION('',(0.,1.));
#192 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#193 = ORIENTED_EDGE('',*,*,#194,.F.);
#194 = EDGE_CURVE('',#195,#167,#197,.T.);
#195 = VERTEX_POINT('',#196);
#196 = CARTESIAN_POINT('',(18.,-10.,2.));
#197 = SURFACE_CURVE('',#198,(#203,#214),.PCURVE_S1.);
#198 = CIRCLE('',#199,2.);
#199 = AXIS2_PLACEMENT_3D('',#200,#201,#202);
#200 = CARTESIAN_POINT('',(16.,-10.,2.));
#201 = DIRECTION('',(-0.,-0.,-1.));
#202 = DIRECTION('',(0.,-1.,0.));
#203 = PCURVE('',#44,#204);
#204 = DEFINITIONAL_REPRESENTATION('',(#205),#213);
#205 = ( BOUNDED_CURVE() B_SPLINE_CURVE(2,(#206,#207,#208,#209,#210,#211
,#212),.UNSPECIFIED.,.T.,.F.) B_SPLINE_CURVE_WITH_KNOTS((1,2,2,2,2,1),(
    -2.094,0.,2.094,4.189,6.283,
8.378),.UNSPECIFIED.) CURVE() GEOMETRIC_REPRESENTATION_ITEM() 
RATIONAL_B_SPLINE_CURVE((1.,0.5,1.,0.5,1.,0.5,1.)) REPRESENTATION_ITEM(
  '') );
#206 = CARTESIAN_POINT('',(34.,0.));
#207 = CARTESIAN_POINT('',(30.536,0.));
#208 = CARTESIAN_POINT('',(32.268,3.));
#209 = CARTESIAN_POINT('',(34.,6.));
#210 = CARTESIAN_POINT('',(35.732,3.));
#211 = CARTESIAN_POINT('',(37.464,0.));
#212 = CARTESIAN_POINT('',(34.,0.));
#213 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#214 = PCURVE('',#215,#220);
#215 = CYLINDRICAL_SURFACE('',#216,2.);
#216 = AXIS2_PLACEMENT_3D('',#217,#218,#219);
#217 = CARTESIAN_POINT('',(16.,-10.,-2.));
#218 = DIRECTION('',(0.,0.,1.));
#219 = DIRECTION('',(1.,0.,-0.));
#220 = DEFINITIONAL_REPRESENTATION('',(#221),#225);
#221 = LINE('',#222,#223);
#222 = CARTESIAN_POINT('',(4.712,4.));
#223 = VECTOR('',#224,1.);
#224 = DIRECTION('',(-1.,0.));
#225 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#226 = ORIENTED_EDGE('',*,*,#227,.T.);
#227 = EDGE_CURVE('',#195,#228,#230,.T.);
#228 = VERTEX_POINT('',#229);
#229 = CARTESIAN_POINT('',(18.,10.,2.));
#230 = SURFACE_CURVE('',#231,(#235,#242),.PCURVE_S1.);
#231 = LINE('',#232,#233);
#232 = CARTESIAN_POINT('',(18.,-12.,2.));
#233 = VECTOR('',#234,1.);
#234 = DIRECTION('',(0.,1.,0.));
#235 = PCURVE('',#44,#236);
#236 = DEFINITIONAL_REPRESENTATION('',(#237),#241);
#237 = LINE('',#238,#239);
#238 = CARTESIAN_POINT('',(36.,0.));
#239 = VECTOR('',#240,1.);
#240 = DIRECTION('',(0.,1.));
#241 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#242 = PCURVE('',#243,#248);
#243 = PLANE('',#244);
#244 = AXIS2_PLACEMENT_3D('',#245,#246,#247);
#245 = CARTESIAN_POINT('',(18.,-12.,-2.));
#246 = DIRECTION('',(1.,0.,0.));
#247 = DIRECTION('',(0.,0.,1.));
#248 = DEFINITIONAL_REPRESENTATION('',(#249),#253);
#249 = LINE('',#250,#251);
#250 = CARTESIAN_POINT('',(4.,0.));
#251 = VECTOR('',#252,1.);
#252 = DIRECTION('',(0.,-1.));
#253 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#254 = ORIENTED_EDGE('',*,*,#255,.T.);
#255 = EDGE_CURVE('',#228,#256,#258,.T.);
#256 = VERTEX_POINT('',#257);
#257 = CARTESIAN_POINT('',(16.,12.,2.));
#258 = SURFACE_CURVE('',#259,(#264,#271),.PCURVE_S1.);
#259 = CIRCLE('',#260,2.);
#260 = AXIS2_PLACEMENT_3D('',#261,#262,#263);
#261 = CARTESIAN_POINT('',(16.,10.,2.));
#262 = DIRECTION('',(0.,0.,1.));
#263 = DIRECTION('',(0.,-1.,0.));
#264 = PCURVE('',#44,#265);
#265 = DEFINITIONAL_REPRESENTATION('',(#266),#270);
#266 = CIRCLE('',#267,2.);
#267 = AXIS2_PLACEMENT_2D('',#268,#269);
#268 = CARTESIAN_POINT('',(34.,22.));
#269 = DIRECTION('',(0.,-1.));
#270 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#271 = PCURVE('',#272,#277);
#272 = CYLINDRICAL_SURFACE('',#273,2.);
#273 = AXIS2_PLACEMENT_3D('',#274,#275,#276);
#274 = CARTESIAN_POINT('',(16.,10.,-2.));
#275 = DIRECTION('',(0.,0.,1.));
#276 = DIRECTION('',(1.,0.,-0.));
#277 = DEFINITIONAL_REPRESENTATION('',(#278),#282);
#278 = LINE('',#279,#280);
#279 = CARTESIAN_POINT('',(-1.571,4.));
#280 = VECTOR('',#281,1.);
#281 = DIRECTION('',(1.,0.));
#282 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#283 = ORIENTED_EDGE('',*,*,#284,.F.);
#284 = EDGE_CURVE('',#285,#256,#287,.T.);
#285 = VERTEX_POINT('',#286);
#286 = CARTESIAN_POINT('',(-16.,12.,2.));
#287 = SURFACE_CURVE('',#288,(#292,#299),.PCURVE_S1.);
#288 = LINE('',#289,#290);
#289 = CARTESIAN_POINT('',(-18.,12.,2.));
#290 = VECTOR('',#291,1.);
#291 = DIRECTION('',(1.,0.,0.));
#292 = PCURVE('',#44,#293);
#293 = DEFINITIONAL_REPRESENTATION('',(#294),#298);
#294 = LINE('',#295,#296);
#295 = CARTESIAN_POINT('',(0.,24.));
#296 = VECTOR('',#297,1.);
#297 = DIRECTION('',(1.,0.));
#298 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#299 = PCURVE('',#300,#305);
#300 = PLANE('',#301);
#301 = AXIS2_PLACEMENT_3D('',#302,#303,#304);
#302 = CARTESIAN_POINT('',(-18.,12.,-2.));
#303 = DIRECTION('',(0.,1.,0.));
#304 = DIRECTION('',(0.,0.,1.));
#305 = DEFINITIONAL_REPRESENTATION('',(#306),#310);
#306 = LINE('',#307,#308);
#307 = CARTESIAN_POINT('',(4.,0.));
#308 = VECTOR('',#309,1.);
#309 = DIRECTION('',(0.,1.));
#310 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#311 = ORIENTED_EDGE('',*,*,#312,.F.);
#312 = EDGE_CURVE('',#24,#285,#313,.T.);
#313 = SURFACE_CURVE('',#314,(#319,#330),.PCURVE_S1.);
#314 = CIRCLE('',#315,2.);
#315 = AXIS2_PLACEMENT_3D('',#316,#317,#318);
#316 = CARTESIAN_POINT('',(-16.,10.,2.));
#317 = DIRECTION('',(-0.,-0.,-1.));
#318 = DIRECTION('',(0.,-1.,0.));
#319 = PCURVE('',#44,#320);
#320 = DEFINITIONAL_REPRESENTATION('',(#321),#329);
#321 = ( BOUNDED_CURVE() B_SPLINE_CURVE(2,(#322,#323,#324,#325,#326,#327
,#328),.UNSPECIFIED.,.T.,.F.) B_SPLINE_CURVE_WITH_KNOTS((1,2,2,2,2,1),(
    -2.094,0.,2.094,4.189,6.283,
8.378),.UNSPECIFIED.) CURVE() GEOMETRIC_REPRESENTATION_ITEM() 
RATIONAL_B_SPLINE_CURVE((1.,0.5,1.,0.5,1.,0.5,1.)) REPRESENTATION_ITEM(
  '') );
#322 = CARTESIAN_POINT('',(2.,20.));
#323 = CARTESIAN_POINT('',(-1.464,20.));
#324 = CARTESIAN_POINT('',(0.268,23.));
#325 = CARTESIAN_POINT('',(2.,26.));
#326 = CARTESIAN_POINT('',(3.732,23.));
#327 = CARTESIAN_POINT('',(5.464,20.));
#328 = CARTESIAN_POINT('',(2.,20.));
#329 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#330 = PCURVE('',#126,#331);
#331 = DEFINITIONAL_REPRESENTATION('',(#332),#336);
#332 = LINE('',#333,#334);
#333 = CARTESIAN_POINT('',(1.571,4.));
#334 = VECTOR('',#335,1.);
#335 = DIRECTION('',(-1.,0.));
#336 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
