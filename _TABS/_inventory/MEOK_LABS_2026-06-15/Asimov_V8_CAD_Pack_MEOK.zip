STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:26',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 16
Bounding box: 60 x 40 x 20 mm (x, y, z)
Volume: 24853.7 mm3; surface area: 11222.3 mm2
Topology: 1 solids, 1 shells, 23 faces, 58 edges, 38 vertices
Faces by surface type: plane 15, cylinder 8
Full cylindrical faces by diameter (mm): 3.4 x2, 6.5 x2
Entity records: 1474 total; most frequent: CARTESIAN_POINT 264, DIRECTION 232, LINE 134, VECTOR 134, ORIENTED_EDGE 116, PCURVE 116, DEFINITIONAL_REPRESENTATION 116, EDGE_CURVE 58
