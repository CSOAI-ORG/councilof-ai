STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:26:42',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 4
Bounding box: 20 x 12 x 8 mm (x, y, z)
Volume: 1492.5 mm3; surface area: 1215.7 mm2
Topology: 1 solids, 1 shells, 27 faces, 72 edges, 48 vertices
Faces by surface type: plane 23, cylinder 4
Entity records: 1772 total; most frequent: CARTESIAN_POINT 336, DIRECTION 256, LINE 180, VECTOR 180, ORIENTED_EDGE 144, PCURVE 144, DEFINITIONAL_REPRESENTATION 144, EDGE_CURVE 72
