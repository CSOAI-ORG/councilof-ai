One B-rep face of a CAD part: STEP entity #690.
In plain terms, this planar face has unit normal (0, -1, 0).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#44 = CYLINDRICAL_SURFACE('',#45,4.);
#45 = AXIS2_PLACEMENT_3D('',#46,#47,#48);
#46 = CARTESIAN_POINT('',(-21.,-6.,-15.));
#47 = DIRECTION('',(0.,0.,1.));
#48 = DIRECTION('',(-1.,-0.,0.));
#72 = PLANE('',#73);
#73 = AXIS2_PLACEMENT_3D('',#74,#75,#76);
#74 = CARTESIAN_POINT('',(-25.,-10.,-15.));
#75 = DIRECTION('',(0.,0.,1.));
#76 = DIRECTION('',(1.,0.,0.));
#143 = VERTEX_POINT('',#144);
#144 = CARTESIAN_POINT('',(-21.,-10.,-15.));
#166 = EDGE_CURVE('',#143,#167,#169,.T.);
#167 = VERTEX_POINT('',#168);
#168 = CARTESIAN_POINT('',(-21.,-10.,14.5));
#169 = SURFACE_CURVE('',#170,(#174,#181),.PCURVE_S1.);
#170 = LINE('',#171,#172);
#171 = CARTESIAN_POINT('',(-21.,-10.,-15.));
#172 = VECTOR('',#173,1.);
#173 = DIRECTION('',(0.,0.,1.));
#174 = PCURVE('',#44,#175);
#175 = DEFINITIONAL_REPRESENTATION('',(#176),#180);
#176 = LINE('',#177,#178);
#177 = CARTESIAN_POINT('',(1.571,0.));
#178 = VECTOR('',#179,1.);
#179 = DIRECTION('',(0.,1.));
#180 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#181 = PCURVE('',#182,#187);
#182 = PLANE('',#183);
#183 = AXIS2_PLACEMENT_3D('',#184,#185,#186);
#184 = CARTESIAN_POINT('',(-25.,-10.,-15.));
#185 = DIRECTION('',(0.,1.,0.));
#186 = DIRECTION('',(0.,0.,1.));
#187 = DEFINITIONAL_REPRESENTATION('',(#188),#192);
#188 = LINE('',#189,#190);
#189 = CARTESIAN_POINT('',(0.,4.));
#190 = VECTOR('',#191,1.);
#191 = DIRECTION('',(1.,0.));
#192 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#303 = EDGE_CURVE('',#143,#304,#306,.T.);
#304 = VERTEX_POINT('',#305);
#305 = CARTESIAN_POINT('',(21.,-10.,-15.));
#306 = SURFACE_CURVE('',#307,(#311,#318),.PCURVE_S1.);
#307 = LINE('',#308,#309);
#308 = CARTESIAN_POINT('',(-25.,-10.,-15.));
#309 = VECTOR('',#310,1.);
#310 = DIRECTION('',(1.,0.,0.));
#311 = PCURVE('',#72,#312);
#312 = DEFINITIONAL_REPRESENTATION('',(#313),#317);
#313 = LINE('',#314,#315);
#314 = CARTESIAN_POINT('',(0.,0.));
#315 = VECTOR('',#316,1.);
#316 = DIRECTION('',(1.,0.));
#317 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#318 = PCURVE('',#182,#319);
#319 = DEFINITIONAL_REPRESENTATION('',(#320),#324);
#320 = LINE('',#321,#322);
#321 = CARTESIAN_POINT('',(0.,0.));
#322 = VECTOR('',#323,1.);
#323 = DIRECTION('',(0.,1.));
#324 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#347 = CYLINDRICAL_SURFACE('',#348,4.);
#348 = AXIS2_PLACEMENT_3D('',#349,#350,#351);
#349 = CARTESIAN_POINT('',(21.,-6.,-15.));
#350 = DIRECTION('',(0.,0.,1.));
#351 = DIRECTION('',(1.,0.,-0.));
#652 = PLANE('',#653);
#653 = AXIS2_PLACEMENT_3D('',#654,#655,#656);
#654 = CARTESIAN_POINT('',(21.,-9.75,14.75));
#655 = DIRECTION('',(0.,0.707,-0.707)
  );
#656 = DIRECTION('',(-1.,0.,0.));
#690 = ADVANCED_FACE('',(#691,#739,#774,#809),#182,.F.);
#691 = FACE_BOUND('',#692,.F.);
#692 = EDGE_LOOP('',(#693,#694,#717,#738));
#693 = ORIENTED_EDGE('',*,*,#166,.T.);
#694 = ORIENTED_EDGE('',*,*,#695,.F.);
#695 = EDGE_CURVE('',#696,#167,#698,.T.);
#696 = VERTEX_POINT('',#697);
#697 = CARTESIAN_POINT('',(21.,-10.,14.5));
#698 = SURFACE_CURVE('',#699,(#703,#710),.PCURVE_S1.);
#699 = LINE('',#700,#701);
#700 = CARTESIAN_POINT('',(21.,-10.,14.5));
#701 = VECTOR('',#702,1.);
#702 = DIRECTION('',(-1.,-0.,-0.));
#703 = PCURVE('',#182,#704);
#704 = DEFINITIONAL_REPRESENTATION('',(#705),#709);
#705 = LINE('',#706,#707);
#706 = CARTESIAN_POINT('',(29.5,46.));
#707 = VECTOR('',#708,1.);
#708 = DIRECTION('',(-0.,-1.));
#709 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#710 = PCURVE('',#652,#711);
#711 = DEFINITIONAL_REPRESENTATION('',(#712),#716);
#712 = LINE('',#713,#714);
#713 = CARTESIAN_POINT('',(0.,-0.354));
#714 = VECTOR('',#715,1.);
#715 = DIRECTION('',(1.,0.));
#716 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#717 = ORIENTED_EDGE('',*,*,#718,.F.);
#718 = EDGE_CURVE('',#304,#696,#719,.T.);
#719 = SURFACE_CURVE('',#720,(#724,#731),.PCURVE_S1.);
#720 = LINE('',#721,#722);
#721 = CARTESIAN_POINT('',(21.,-10.,-15.));
#722 = VECTOR('',#723,1.);
#723 = DIRECTION('',(0.,0.,1.));
#724 = PCURVE('',#182,#725);
#725 = DEFINITIONAL_REPRESENTATION('',(#726),#730);
#726 = LINE('',#727,#728);
#727 = CARTESIAN_POINT('',(0.,46.));
#728 = VECTOR('',#729,1.);
#729 = DIRECTION('',(1.,0.));
#730 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#731 = PCURVE('',#347,#732);
#732 = DEFINITIONAL_REPRESENTATION('',(#733),#737);
#733 = LINE('',#734,#735);
#734 = CARTESIAN_POINT('',(-1.571,0.));
#735 = VECTOR('',#736,1.);
#736 = DIRECTION('',(-0.,1.));
#737 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#738 = ORIENTED_EDGE('',*,*,#303,.F.);
#739 = FACE_BOUND('',#740,.F.);
#740 = EDGE_LOOP('',(#741));
#741 = ORIENTED_EDGE('',*,*,#742,.T.);
#742 = EDGE_CURVE('',#743,#743,#745,.T.);
#743 = VERTEX_POINT('',#744);
#744 = CARTESIAN_POINT('',(-12.9,-10.,0.));
#745 = SURFACE_CURVE('',#746,(#751,#762),.PCURVE_S1.);
#746 = CIRCLE('',#747,2.1);
#747 = AXIS2_PLACEMENT_3D('',#748,#749,#750);
#748 = CARTESIAN_POINT('',(-15.,-10.,0.));
#749 = DIRECTION('',(-0.,-1.,0.));
#750 = DIRECTION('',(1.,-0.,0.));
#751 = PCURVE('',#182,#752);
#752 = DEFINITIONAL_REPRESENTATION('',(#753),#761);
#753 = ( BOUNDED_CURVE() B_SPLINE_CURVE(2,(#754,#755,#756,#757,#758,#759
,#760),.UNSPECIFIED.,.T.,.F.) B_SPLINE_CURVE_WITH_KNOTS((1,2,2,2,2,1),(
    -2.094,0.,2.094,4.189,6.283,
8.378),.UNSPECIFIED.) CURVE() GEOMETRIC_REPRESENTATION_ITEM() 
RATIONAL_B_SPLINE_CURVE((1.,0.5,1.,0.5,1.,0.5,1.)) REPRESENTATION_ITEM(
  '') );
#754 = CARTESIAN_POINT('',(15.,12.1));
#755 = CARTESIAN_POINT('',(18.637,12.1));
#756 = CARTESIAN_POINT('',(16.819,8.95));
#757 = CARTESIAN_POINT('',(15.,5.8));
#758 = CARTESIAN_POINT('',(13.181,8.95));
#759 = CARTESIAN_POINT('',(11.363,12.1));
#760 = CARTESIAN_POINT('',(15.,12.1));
#761 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#762 = PCURVE('',#763,#768);
#763 = CYLINDRICAL_SURFACE('',#764,2.1);
#764 = AXIS2_PLACEMENT_3D('',#765,#766,#767);
#765 = CARTESIAN_POINT('',(-15.,10.,0.));
#766 = DIRECTION('',(0.,-1.,0.));
#767 = DIRECTION('',(1.,-0.,0.));
#768 = DEFINITIONAL_REPRESENTATION('',(#769),#773);
#769 = LINE('',#770,#771);
#770 = CARTESIAN_POINT('',(0.,20.));
#771 = VECTOR('',#772,1.);
#772 = DIRECTION('',(1.,0.));
#773 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#774 = FACE_BOUND('',#775,.F.);
#775 = EDGE_LOOP('',(#776));
#776 = ORIENTED_EDGE('',*,*,#777,.T.);
#777 = EDGE_CURVE('',#778,#778,#780,.T.);
#778 = VERTEX_POINT('',#779);
#779 = CARTESIAN_POINT('',(2.1,-10.,0.));
#780 = SURFACE_CURVE('',#781,(#786,#797),.PCURVE_S1.);
#781 = CIRCLE('',#782,2.1);
#782 = AXIS2_PLACEMENT_3D('',#783,#784,#785);
#783 = CARTESIAN_POINT('',(0.,-10.,0.));
#784 = DIRECTION('',(-0.,-1.,0.));
#785 = DIRECTION('',(1.,-0.,0.));
#786 = PCURVE('',#182,#787);
#787 = DEFINITIONAL_REPRESENTATION('',(#788),#796);
#788 = ( BOUNDED_CURVE() B_SPLINE_CURVE(2,(#789,#790,#791,#792,#793,#794
,#795),.UNSPECIFIED.,.T.,.F.) B_SPLINE_CURVE_WITH_KNOTS((1,2,2,2,2,1),(
    -2.094,0.,2.094,4.189,6.283,
8.378),.UNSPECIFIED.) CURVE() GEOMETRIC_REPRESENTATION_ITEM() 
RATIONAL_B_SPLINE_CURVE((1.,0.5,1.,0.5,1.,0.5,1.)) REPRESENTATION_ITEM(
  '') );
#789 = CARTESIAN_POINT('',(15.,27.1));
#790 = CARTESIAN_POINT('',(18.637,27.1));
#791 = CARTESIAN_POINT('',(16.819,23.95));
#792 = CARTESIAN_POINT('',(15.,20.8));
#793 = CARTESIAN_POINT('',(13.181,23.95));
#794 = CARTESIAN_POINT('',(11.363,27.1));
#795 = CARTESIAN_POINT('',(15.,27.1));
#796 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#797 = PCURVE('',#798,#803);
#798 = CYLINDRICAL_SURFACE('',#799,2.1);
#799 = AXIS2_PLACEMENT_3D('',#800,#801,#802);
#800 = CARTESIAN_POINT('',(0.,10.,0.));
#801 = DIRECTION('',(0.,-1.,0.));
#802 = DIRECTION('',(1.,-0.,0.));
#803 = DEFINITIONAL_REPRESENTATION('',(#804),#808);
#804 = LINE('',#805,#806);
#805 = CARTESIAN_POINT('',(0.,20.));
#806 = VECTOR('',#807,1.);
#807 = DIRECTION('',(1.,0.));
#808 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#809 = FACE_BOUND('',#810,.F.);
#810 = EDGE_LOOP('',(#811));
#811 = ORIENTED_EDGE('',*,*,#812,.T.);
#812 = EDGE_CURVE('',#813,#813,#815,.T.);
#813 = VERTEX_POINT('',#814);
#814 = CARTESIAN_POINT('',(17.1,-10.,0.));
#815 = SURFACE_CURVE('',#816,(#821,#832),.PCURVE_S1.);
#816 = CIRCLE('',#817,2.1);
#817 = AXIS2_PLACEMENT_3D('',#818,#819,#820);
#818 = CARTESIAN_POINT('',(15.,-10.,0.));
#819 = DIRECTION('',(-0.,-1.,0.));
#820 = DIRECTION('',(1.,-0.,0.));
#821 = PCURVE('',#182,#822);
#822 = DEFINITIONAL_REPRESENTATION('',(#823),#831);
#823 = ( BOUNDED_CURVE() B_SPLINE_CURVE(2,(#824,#825,#826,#827,#828,#829
,#830),.UNSPECIFIED.,.T.,.F.) B_SPLINE_CURVE_WITH_KNOTS((1,2,2,2,2,1),(
    -2.094,0.,2.094,4.189,6.283,
8.378),.UNSPECIFIED.) CURVE() GEOMETRIC_REPRESENTATION_ITEM() 
RATIONAL_B_SPLINE_CURVE((1.,0.5,1.,0.5,1.,0.5,1.)) REPRESENTATION_ITEM(
  '') );
#824 = CARTESIAN_POINT('',(15.,42.1));
#825 = CARTESIAN_POINT('',(18.637,42.1));
#826 = CARTESIAN_POINT('',(16.819,38.95));
#827 = CARTESIAN_POINT('',(15.,35.8));
#828 = CARTESIAN_POINT('',(13.181,38.95));
#829 = CARTESIAN_POINT('',(11.363,42.1));
#830 = CARTESIAN_POINT('',(15.,42.1));
#831 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#832 = PCURVE('',#833,#838);
#833 = CYLINDRICAL_SURFACE('',#834,2.1);
#834 = AXIS2_PLACEMENT_3D('',#835,#836,#837);
#835 = CARTESIAN_POINT('',(15.,10.,0.));
#836 = DIRECTION('',(0.,-1.,0.));
#837 = DIRECTION('',(1.,-0.,0.));
#838 = DEFINITIONAL_REPRESENTATION('',(#839),#843);
#839 = LINE('',#840,#841);
#840 = CARTESIAN_POINT('',(0.,20.));
#841 = VECTOR('',#842,1.);
#842 = DIRECTION('',(1.,0.));
#843 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
