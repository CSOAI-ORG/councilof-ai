STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:21',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 2
Bounding box: 140 x 50 x 65 mm (x, y, z)
Volume: 65367.2 mm3; surface area: 23239.9 mm2
Topology: 1 solids, 1 shells, 39 faces, 95 edges, 62 vertices
Faces by surface type: plane 26, cylinder 13
Full cylindrical faces by diameter (mm): 5.5 x4, 10 x4, 30 x1
Entity records: 2423 total; most frequent: CARTESIAN_POINT 417, DIRECTION 386, LINE 233, VECTOR 233, ORIENTED_EDGE 190, PCURVE 190, DEFINITIONAL_REPRESENTATION 190, EDGE_CURVE 95
