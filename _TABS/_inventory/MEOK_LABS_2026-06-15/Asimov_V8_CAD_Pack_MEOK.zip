STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:25',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 12
Bounding box: 40 x 60 x 8 mm (x, y, z)
Volume: 19066.1 mm3; surface area: 6260.7 mm2
Topology: 1 solids, 1 shells, 18 faces, 40 edges, 24 vertices
Faces by surface type: plane 10, cylinder 4, cone 4
Entity records: 1024 total; most frequent: CARTESIAN_POINT 215, DIRECTION 148, LINE 84, VECTOR 84, ORIENTED_EDGE 80, PCURVE 80, DEFINITIONAL_REPRESENTATION 80, EDGE_CURVE 40
