STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:26:43',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 13
Bounding box: 160 x 3 x 60 mm (x, y, z)
Volume: 22011 mm3; surface area: 19043.5 mm2
Topology: 1 solids, 1 shells, 22 faces, 60 edges, 40 vertices
Faces by surface type: plane 18, cylinder 4
Full cylindrical faces by diameter (mm): 3.4 x4
Entity records: 1486 total; most frequent: CARTESIAN_POINT 259, DIRECTION 218, LINE 148, VECTOR 148, ORIENTED_EDGE 120, PCURVE 120, DEFINITIONAL_REPRESENTATION 120, EDGE_CURVE 60
