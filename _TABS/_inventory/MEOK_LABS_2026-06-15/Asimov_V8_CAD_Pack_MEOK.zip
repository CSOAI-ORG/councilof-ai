One B-rep face of a CAD part: STEP entity #1568.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#358 = PLANE('',#359);
#359 = AXIS2_PLACEMENT_3D('',#360,#361,#362);
#360 = CARTESIAN_POINT('',(-25.,-15.,10.));
#361 = DIRECTION('',(0.,-1.,0.));
#362 = DIRECTION('',(1.,0.,0.));
#386 = PLANE('',#387);
#387 = AXIS2_PLACEMENT_3D('',#388,#389,#390);
#388 = CARTESIAN_POINT('',(-25.,15.,10.));
#389 = DIRECTION('',(-1.,0.,0.));
#390 = DIRECTION('',(0.,-1.,0.));
#414 = PLANE('',#415);
#415 = AXIS2_PLACEMENT_3D('',#416,#417,#418);
#416 = CARTESIAN_POINT('',(25.,15.,10.));
#417 = DIRECTION('',(0.,1.,-0.));
#418 = DIRECTION('',(-1.,0.,0.));
#443 = CYLINDRICAL_SURFACE('',#444,1.7);
#444 = AXIS2_PLACEMENT_3D('',#445,#446,#447);
#445 = CARTESIAN_POINT('',(-5.,15.,-10.));
#446 = DIRECTION('',(0.,0.,1.));
#447 = DIRECTION('',(-1.,0.,0.));
#471 = PLANE('',#472);
#472 = AXIS2_PLACEMENT_3D('',#473,#474,#475);
#473 = CARTESIAN_POINT('',(25.,15.,10.));
#474 = DIRECTION('',(0.,1.,-0.));
#475 = DIRECTION('',(-1.,0.,0.));
#499 = PLANE('',#500);
#500 = AXIS2_PLACEMENT_3D('',#501,#502,#503);
#501 = CARTESIAN_POINT('',(25.,-15.,10.));
#502 = DIRECTION('',(1.,0.,0.));
#503 = DIRECTION('',(-0.,1.,0.));
#527 = PLANE('',#528);
#528 = AXIS2_PLACEMENT_3D('',#529,#530,#531);
#529 = CARTESIAN_POINT('',(-25.,-15.,10.));
#530 = DIRECTION('',(0.,-1.,0.));
#531 = DIRECTION('',(1.,0.,0.));
#554 = CYLINDRICAL_SURFACE('',#555,1.7);
#555 = AXIS2_PLACEMENT_3D('',#556,#557,#558);
#556 = CARTESIAN_POINT('',(-5.,-15.,-10.));
#557 = DIRECTION('',(0.,0.,1.));
#558 = DIRECTION('',(-1.,0.,0.));
#977 = VERTEX_POINT('',#978);
#978 = CARTESIAN_POINT('',(-25.,-15.,-5.));
#999 = EDGE_CURVE('',#977,#1000,#1002,.T.);
#1000 = VERTEX_POINT('',#1001);
#1001 = CARTESIAN_POINT('',(-6.7,-15.,-5.));
#1002 = SURFACE_CURVE('',#1003,(#1007,#1014),.PCURVE_S1.);
#1003 = LINE('',#1004,#1005);
#1004 = CARTESIAN_POINT('',(-25.,-15.,-5.));
#1005 = VECTOR('',#1006,1.);
#1006 = DIRECTION('',(1.,0.,0.));
#1007 = PCURVE('',#358,#1008);
#1008 = DEFINITIONAL_REPRESENTATION('',(#1009),#1013);
#1009 = LINE('',#1010,#1011);
#1010 = CARTESIAN_POINT('',(0.,-15.));
#1011 = VECTOR('',#1012,1.);
#1012 = DIRECTION('',(1.,0.));
#1013 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1014 = PCURVE('',#1015,#1020);
#1015 = PLANE('',#1016);
#1016 = AXIS2_PLACEMENT_3D('',#1017,#1018,#1019);
#1017 = CARTESIAN_POINT('',(0.,0.,-5.));
#1018 = DIRECTION('',(0.,0.,1.));
#1019 = DIRECTION('',(1.,0.,-0.));
#1020 = DEFINITIONAL_REPRESENTATION('',(#1021),#1025);
#1021 = LINE('',#1022,#1023);
#1022 = CARTESIAN_POINT('',(-25.,-15.));
#1023 = VECTOR('',#1024,1.);
#1024 = DIRECTION('',(1.,0.));
#1025 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1101 = EDGE_CURVE('',#1102,#1000,#1104,.T.);
#1102 = VERTEX_POINT('',#1103);
#1103 = CARTESIAN_POINT('',(-3.3,-15.,-5.));
#1104 = SURFACE_CURVE('',#1105,(#1110,#1117),.PCURVE_S1.);
#1105 = CIRCLE('',#1106,1.7);
#1106 = AXIS2_PLACEMENT_3D('',#1107,#1108,#1109);
#1107 = CARTESIAN_POINT('',(-5.,-15.,-5.));
#1108 = DIRECTION('',(0.,0.,1.));
#1109 = DIRECTION('',(-1.,0.,0.));
#1110 = PCURVE('',#554,#1111);
#1111 = DEFINITIONAL_REPRESENTATION('',(#1112),#1116);
#1112 = LINE('',#1113,#1114);
#1113 = CARTESIAN_POINT('',(0.,5.));
#1114 = VECTOR('',#1115,1.);
#1115 = DIRECTION('',(1.,0.));
#1116 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1117 = PCURVE('',#1015,#1118);
#1118 = DEFINITIONAL_REPRESENTATION('',(#1119),#1123);
#1119 = CIRCLE('',#1120,1.7);
#1120 = AXIS2_PLACEMENT_2D('',#1121,#1122);
#1121 = CARTESIAN_POINT('',(-5.,-15.));
#1122 = DIRECTION('',(-1.,0.));
#1123 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1152 = EDGE_CURVE('',#1102,#1153,#1155,.T.);
#1153 = VERTEX_POINT('',#1154);
#1154 = CARTESIAN_POINT('',(25.,-15.,-5.));
#1155 = SURFACE_CURVE('',#1156,(#1160,#1167),.PCURVE_S1.);
#1156 = LINE('',#1157,#1158);
#1157 = CARTESIAN_POINT('',(-25.,-15.,-5.));
#1158 = VECTOR('',#1159,1.);
#1159 = DIRECTION('',(1.,0.,0.));
#1160 = PCURVE('',#527,#1161);
#1161 = DEFINITIONAL_REPRESENTATION('',(#1162),#1166);
#1162 = LINE('',#1163,#1164);
#1163 = CARTESIAN_POINT('',(0.,-15.));
#1164 = VECTOR('',#1165,1.);
#1165 = DIRECTION('',(1.,0.));
#1166 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1167 = PCURVE('',#1015,#1168);
#1168 = DEFINITIONAL_REPRESENTATION('',(#1169),#1173);
#1169 = LINE('',#1170,#1171);
#1170 = CARTESIAN_POINT('',(-25.,-15.));
#1171 = VECTOR('',#1172,1.);
#1172 = DIRECTION('',(1.,0.));
#1173 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1200 = EDGE_CURVE('',#1153,#1201,#1203,.T.);
#1201 = VERTEX_POINT('',#1202);
#1202 = CARTESIAN_POINT('',(25.,15.,-5.));
#1203 = SURFACE_CURVE('',#1204,(#1208,#1215),.PCURVE_S1.);
#1204 = LINE('',#1205,#1206);
#1205 = CARTESIAN_POINT('',(25.,-15.,-5.));
#1206 = VECTOR('',#1207,1.);
#1207 = DIRECTION('',(0.,1.,0.));
#1208 = PCURVE('',#499,#1209);
#1209 = DEFINITIONAL_REPRESENTATION('',(#1210),#1214);
#1210 = LINE('',#1211,#1212);
#1211 = CARTESIAN_POINT('',(0.,-15.));
#1212 = VECTOR('',#1213,1.);
#1213 = DIRECTION('',(1.,0.));
#1214 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1215 = PCURVE('',#1015,#1216);
#1216 = DEFINITIONAL_REPRESENTATION('',(#1217),#1221);
#1217 = LINE('',#1218,#1219);
#1218 = CARTESIAN_POINT('',(25.,-15.));
#1219 = VECTOR('',#1220,1.);
#1220 = DIRECTION('',(0.,1.));
#1221 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1250 = EDGE_CURVE('',#1201,#1251,#1253,.T.);
#1251 = VERTEX_POINT('',#1252);
#1252 = CARTESIAN_POINT('',(-3.3,15.,-5.));
#1253 = SURFACE_CURVE('',#1254,(#1258,#1265),.PCURVE_S1.);
#1254 = LINE('',#1255,#1256);
#1255 = CARTESIAN_POINT('',(25.,15.,-5.));
#1256 = VECTOR('',#1257,1.);
#1257 = DIRECTION('',(-1.,0.,0.));
#1258 = PCURVE('',#471,#1259);
#1259 = DEFINITIONAL_REPRESENTATION('',(#1260),#1264);
#1260 = LINE('',#1261,#1262);
#1261 = CARTESIAN_POINT('',(0.,-15.));
#1262 = VECTOR('',#1263,1.);
#1263 = DIRECTION('',(1.,0.));
#1264 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1265 = PCURVE('',#1015,#1266);
#1266 = DEFINITIONAL_REPRESENTATION('',(#1267),#1271);
#1267 = LINE('',#1268,#1269);
#1268 = CARTESIAN_POINT('',(25.,15.));
#1269 = VECTOR('',#1270,1.);
#1270 = DIRECTION('',(-1.,0.));
#1271 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1325 = VERTEX_POINT('',#1326);
#1326 = CARTESIAN_POINT('',(-6.7,15.,-5.));
#1370 = EDGE_CURVE('',#1325,#1251,#1371,.T.);
#1371 = SURFACE_CURVE('',#1372,(#1377,#1384),.PCURVE_S1.);
#1372 = CIRCLE('',#1373,1.7);
#1373 = AXIS2_PLACEMENT_3D('',#1374,#1375,#1376);
#1374 = CARTESIAN_POINT('',(-5.,15.,-5.));
#1375 = DIRECTION('',(0.,0.,1.));
#1376 = DIRECTION('',(-1.,0.,0.));
#1377 = PCURVE('',#443,#1378);
#1378 = DEFINITIONAL_REPRESENTATION('',(#1379),#1383);
#1379 = LINE('',#1380,#1381);
#1380 = CARTESIAN_POINT('',(0.,5.));
#1381 = VECTOR('',#1382,1.);
#1382 = DIRECTION('',(1.,0.));
#1383 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1384 = PCURVE('',#1015,#1385);
#1385 = DEFINITIONAL_REPRESENTATION('',(#1386),#1390);
#1386 = CIRCLE('',#1387,1.7);
#1387 = AXIS2_PLACEMENT_2D('',#1388,#1389);
#1388 = CARTESIAN_POINT('',(-5.,15.));
#1389 = DIRECTION('',(-1.,0.));
#1390 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1398 = EDGE_CURVE('',#1325,#1399,#1401,.T.);
#1399 = VERTEX_POINT('',#1400);
#1400 = CARTESIAN_POINT('',(-25.,15.,-5.));
#1401 = SURFACE_CURVE('',#1402,(#1406,#1413),.PCURVE_S1.);
#1402 = LINE('',#1403,#1404);
#1403 = CARTESIAN_POINT('',(25.,15.,-5.));
#1404 = VECTOR('',#1405,1.);
#1405 = DIRECTION('',(-1.,0.,0.));
#1406 = PCURVE('',#414,#1407);
#1407 = DEFINITIONAL_REPRESENTATION('',(#1408),#1412);
#1408 = LINE('',#1409,#1410);
#1409 = CARTESIAN_POINT('',(0.,-15.));
#1410 = VECTOR('',#1411,1.);
#1411 = DIRECTION('',(1.,0.));
#1412 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1413 = PCURVE('',#1015,#1414);
#1414 = DEFINITIONAL_REPRESENTATION('',(#1415),#1419);
#1415 = LINE('',#1416,#1417);
#1416 = CARTESIAN_POINT('',(25.,15.));
#1417 = VECTOR('',#1418,1.);
#1418 = DIRECTION('',(-1.,0.));
#1419 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1446 = EDGE_CURVE('',#1399,#977,#1447,.T.);
#1447 = SURFACE_CURVE('',#1448,(#1452,#1459),.PCURVE_S1.);
#1448 = LINE('',#1449,#1450);
#1449 = CARTESIAN_POINT('',(-25.,15.,-5.));
#1450 = VECTOR('',#1451,1.);
#1451 = DIRECTION('',(0.,-1.,0.));
#1452 = PCURVE('',#386,#1453);
#1453 = DEFINITIONAL_REPRESENTATION('',(#1454),#1458);
#1454 = LINE('',#1455,#1456);
#1455 = CARTESIAN_POINT('',(0.,-15.));
#1456 = VECTOR('',#1457,1.);
#1457 = DIRECTION('',(1.,0.));
#1458 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1459 = PCURVE('',#1015,#1460);
#1460 = DEFINITIONAL_REPRESENTATION('',(#1461),#1465);
#1461 = LINE('',#1462,#1463);
#1462 = CARTESIAN_POINT('',(-25.,15.));
#1463 = VECTOR('',#1464,1.);
#1464 = DIRECTION('',(0.,-1.));
#1465 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1568 = ADVANCED_FACE('',(#1569),#1015,.T.);
#1569 = FACE_BOUND('',#1570,.T.);
#1570 = EDGE_LOOP('',(#1571,#1572,#1573,#1574,#1575,#1576,#1577,#1578));
#1571 = ORIENTED_EDGE('',*,*,#1446,.T.);
#1572 = ORIENTED_EDGE('',*,*,#999,.T.);
#1573 = ORIENTED_EDGE('',*,*,#1101,.F.);
#1574 = ORIENTED_EDGE('',*,*,#1152,.T.);
#1575 = ORIENTED_EDGE('',*,*,#1200,.T.);
#1576 = ORIENTED_EDGE('',*,*,#1250,.T.);
#1577 = ORIENTED_EDGE('',*,*,#1370,.F.);
#1578 = ORIENTED_EDGE('',*,*,#1398,.T.);
