STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:28',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 26
Bounding box: 200 x 30 x 8 mm (x, y, z)
Volume: 46381.4 mm3; surface area: 15775.1 mm2
Topology: 1 solids, 1 shells, 22 faces, 52 edges, 32 vertices
Faces by surface type: plane 10, cylinder 8, cone 4
Full cylindrical faces by diameter (mm): 3.4 x2, 8 x1, 12 x1
Entity records: 1360 total; most frequent: CARTESIAN_POINT 311, DIRECTION 192, ORIENTED_EDGE 104, LINE 104, VECTOR 104, PCURVE 104, DEFINITIONAL_REPRESENTATION 104, EDGE_CURVE 52
