STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:45',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 4
Bounding box: 40 x 25 x 12 mm (x, y, z)
Volume: 7011.3 mm3; surface area: 4314.7 mm2
Topology: 1 solids, 1 shells, 15 faces, 36 edges, 24 vertices
Faces by surface type: plane 11, cylinder 4
Entity records: 928 total; most frequent: CARTESIAN_POINT 172, DIRECTION 144, LINE 92, VECTOR 92, ORIENTED_EDGE 72, PCURVE 72, DEFINITIONAL_REPRESENTATION 72, EDGE_CURVE 36
