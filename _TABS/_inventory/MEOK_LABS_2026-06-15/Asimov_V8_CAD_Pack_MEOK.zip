STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:49',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 3
Bounding box: 90 x 62 x 10 mm (x, y, z)
Volume: 23097.1 mm3; surface area: 13316 mm2
Topology: 1 solids, 1 shells, 26 faces, 60 edges, 40 vertices
Faces by surface type: cylinder 16, plane 10
Full cylindrical faces by diameter (mm): 2.7 x4, 3.4 x4, 8 x4
Entity records: 1614 total; most frequent: CARTESIAN_POINT 319, DIRECTION 254, ORIENTED_EDGE 120, PCURVE 120, DEFINITIONAL_REPRESENTATION 120, LINE 116, VECTOR 116, EDGE_CURVE 60
