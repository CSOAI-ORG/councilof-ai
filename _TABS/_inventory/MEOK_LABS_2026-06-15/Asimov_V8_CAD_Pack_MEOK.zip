One B-rep face of a CAD part: STEP entity #1304.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#358 = PLANE('',#359);
#359 = AXIS2_PLACEMENT_3D('',#360,#361,#362);
#360 = CARTESIAN_POINT('',(-80.,-35.,100.));
#361 = DIRECTION('',(0.,-1.,0.));
#362 = DIRECTION('',(1.,0.,0.));
#386 = PLANE('',#387);
#387 = AXIS2_PLACEMENT_3D('',#388,#389,#390);
#388 = CARTESIAN_POINT('',(-80.,35.,100.));
#389 = DIRECTION('',(-1.,0.,0.));
#390 = DIRECTION('',(0.,-1.,0.));
#414 = PLANE('',#415);
#415 = AXIS2_PLACEMENT_3D('',#416,#417,#418);
#416 = CARTESIAN_POINT('',(80.,35.,100.));
#417 = DIRECTION('',(0.,1.,-0.));
#418 = DIRECTION('',(-1.,0.,0.));
#440 = PLANE('',#441);
#441 = AXIS2_PLACEMENT_3D('',#442,#443,#444);
#442 = CARTESIAN_POINT('',(80.,-35.,100.));
#443 = DIRECTION('',(1.,0.,0.));
#444 = DIRECTION('',(-0.,1.,0.));
#1042 = VERTEX_POINT('',#1043);
#1043 = CARTESIAN_POINT('',(-80.,-35.,-90.));
#1064 = EDGE_CURVE('',#1042,#1065,#1067,.T.);
#1065 = VERTEX_POINT('',#1066);
#1066 = CARTESIAN_POINT('',(80.,-35.,-90.));
#1067 = SURFACE_CURVE('',#1068,(#1072,#1079),.PCURVE_S1.);
#1068 = LINE('',#1069,#1070);
#1069 = CARTESIAN_POINT('',(-80.,-35.,-90.));
#1070 = VECTOR('',#1071,1.);
#1071 = DIRECTION('',(1.,0.,0.));
#1072 = PCURVE('',#358,#1073);
#1073 = DEFINITIONAL_REPRESENTATION('',(#1074),#1078);
#1074 = LINE('',#1075,#1076);
#1075 = CARTESIAN_POINT('',(0.,-190.));
#1076 = VECTOR('',#1077,1.);
#1077 = DIRECTION('',(1.,0.));
#1078 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1079 = PCURVE('',#1080,#1085);
#1080 = PLANE('',#1081);
#1081 = AXIS2_PLACEMENT_3D('',#1082,#1083,#1084);
#1082 = CARTESIAN_POINT('',(0.,0.,-90.));
#1083 = DIRECTION('',(0.,0.,1.));
#1084 = DIRECTION('',(1.,0.,-0.));
#1085 = DEFINITIONAL_REPRESENTATION('',(#1086),#1090);
#1086 = LINE('',#1087,#1088);
#1087 = CARTESIAN_POINT('',(-80.,-35.));
#1088 = VECTOR('',#1089,1.);
#1089 = DIRECTION('',(1.,0.));
#1090 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1118 = EDGE_CURVE('',#1065,#1119,#1121,.T.);
#1119 = VERTEX_POINT('',#1120);
#1120 = CARTESIAN_POINT('',(80.,35.,-90.));
#1121 = SURFACE_CURVE('',#1122,(#1126,#1133),.PCURVE_S1.);
#1122 = LINE('',#1123,#1124);
#1123 = CARTESIAN_POINT('',(80.,-35.,-90.));
#1124 = VECTOR('',#1125,1.);
#1125 = DIRECTION('',(0.,1.,0.));
#1126 = PCURVE('',#440,#1127);
#1127 = DEFINITIONAL_REPRESENTATION('',(#1128),#1132);
#1128 = LINE('',#1129,#1130);
#1129 = CARTESIAN_POINT('',(0.,-190.));
#1130 = VECTOR('',#1131,1.);
#1131 = DIRECTION('',(1.,0.));
#1132 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1133 = PCURVE('',#1080,#1134);
#1134 = DEFINITIONAL_REPRESENTATION('',(#1135),#1139);
#1135 = LINE('',#1136,#1137);
#1136 = CARTESIAN_POINT('',(80.,-35.));
#1137 = VECTOR('',#1138,1.);
#1138 = DIRECTION('',(0.,1.));
#1139 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1167 = EDGE_CURVE('',#1119,#1168,#1170,.T.);
#1168 = VERTEX_POINT('',#1169);
#1169 = CARTESIAN_POINT('',(-80.,35.,-90.));
#1170 = SURFACE_CURVE('',#1171,(#1175,#1182),.PCURVE_S1.);
#1171 = LINE('',#1172,#1173);
#1172 = CARTESIAN_POINT('',(80.,35.,-90.));
#1173 = VECTOR('',#1174,1.);
#1174 = DIRECTION('',(-1.,0.,0.));
#1175 = PCURVE('',#414,#1176);
#1176 = DEFINITIONAL_REPRESENTATION('',(#1177),#1181);
#1177 = LINE('',#1178,#1179);
#1178 = CARTESIAN_POINT('',(0.,-190.));
#1179 = VECTOR('',#1180,1.);
#1180 = DIRECTION('',(1.,0.));
#1181 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1182 = PCURVE('',#1080,#1183);
#1183 = DEFINITIONAL_REPRESENTATION('',(#1184),#1188);
#1184 = LINE('',#1185,#1186);
#1185 = CARTESIAN_POINT('',(80.,35.));
#1186 = VECTOR('',#1187,1.);
#1187 = DIRECTION('',(-1.,0.));
#1188 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1216 = EDGE_CURVE('',#1168,#1042,#1217,.T.);
#1217 = SURFACE_CURVE('',#1218,(#1222,#1229),.PCURVE_S1.);
#1218 = LINE('',#1219,#1220);
#1219 = CARTESIAN_POINT('',(-80.,35.,-90.));
#1220 = VECTOR('',#1221,1.);
#1221 = DIRECTION('',(0.,-1.,0.));
#1222 = PCURVE('',#386,#1223);
#1223 = DEFINITIONAL_REPRESENTATION('',(#1224),#1228);
#1224 = LINE('',#1225,#1226);
#1225 = CARTESIAN_POINT('',(0.,-190.));
#1226 = VECTOR('',#1227,1.);
#1227 = DIRECTION('',(1.,0.));
#1228 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1229 = PCURVE('',#1080,#1230);
#1230 = DEFINITIONAL_REPRESENTATION('',(#1231),#1235);
#1231 = LINE('',#1232,#1233);
#1232 = CARTESIAN_POINT('',(-80.,35.));
#1233 = VECTOR('',#1234,1.);
#1234 = DIRECTION('',(0.,-1.));
#1235 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1304 = ADVANCED_FACE('',(#1305),#1080,.T.);
#1305 = FACE_BOUND('',#1306,.T.);
#1306 = EDGE_LOOP('',(#1307,#1308,#1309,#1310));
#1307 = ORIENTED_EDGE('',*,*,#1064,.T.);
#1308 = ORIENTED_EDGE('',*,*,#1118,.T.);
#1309 = ORIENTED_EDGE('',*,*,#1167,.T.);
#1310 = ORIENTED_EDGE('',*,*,#1216,.T.);
