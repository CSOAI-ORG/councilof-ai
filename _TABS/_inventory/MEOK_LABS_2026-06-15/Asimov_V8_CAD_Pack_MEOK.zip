STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:25',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 13
Bounding box: 40 x 25 x 5 mm (x, y, z)
Volume: 4537 mm3; surface area: 2905.6 mm2
Topology: 1 solids, 1 shells, 40 faces, 106 edges, 68 vertices
Faces by surface type: plane 24, cylinder 12, cone 4
Full cylindrical faces by diameter (mm): 2.2 x4, 6.5 x2
Entity records: 2658 total; most frequent: CARTESIAN_POINT 563, DIRECTION 376, LINE 218, VECTOR 218, ORIENTED_EDGE 212, PCURVE 212, DEFINITIONAL_REPRESENTATION 212, EDGE_CURVE 106
