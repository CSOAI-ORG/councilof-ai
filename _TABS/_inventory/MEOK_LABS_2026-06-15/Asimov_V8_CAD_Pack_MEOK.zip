STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:27',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 20
Bounding box: 90 x 90 x 3 mm (x, y, z)
Volume: 18378.9 mm3; surface area: 13393.1 mm2
Topology: 1 solids, 1 shells, 11 faces, 26 edges, 17 vertices
Faces by surface type: cylinder 8, plane 2, cone 1
Full cylindrical faces by diameter (mm): 3.4 x6, 15 x1, 90 x1
Entity records: 742 total; most frequent: CARTESIAN_POINT 187, DIRECTION 104, ORIENTED_EDGE 52, PCURVE 52, DEFINITIONAL_REPRESENTATION 52, LINE 43, VECTOR 43, AXIS2_PLACEMENT_3D 29
