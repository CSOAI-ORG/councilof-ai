One B-rep face of a CAD part: STEP entity #377.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#133 = CYLINDRICAL_SURFACE('',#134,1.7);
#134 = AXIS2_PLACEMENT_3D('',#135,#136,#137);
#135 = CARTESIAN_POINT('',(0.,-22.,3.));
#136 = DIRECTION('',(0.,0.,-1.));
#137 = DIRECTION('',(-1.,0.,0.));
#168 = CYLINDRICAL_SURFACE('',#169,1.7);
#169 = AXIS2_PLACEMENT_3D('',#170,#171,#172);
#170 = CARTESIAN_POINT('',(0.,22.,3.));
#171 = DIRECTION('',(0.,0.,-1.));
#172 = DIRECTION('',(-1.,0.,0.));
#203 = CYLINDRICAL_SURFACE('',#204,25.);
#204 = AXIS2_PLACEMENT_3D('',#205,#206,#207);
#205 = CARTESIAN_POINT('',(0.,0.,3.));
#206 = DIRECTION('',(0.,0.,1.));
#207 = DIRECTION('',(1.,0.,0.));
#219 = VERTEX_POINT('',#220);
#220 = CARTESIAN_POINT('',(-1.7,-22.,1.));
#243 = EDGE_CURVE('',#219,#219,#244,.T.);
#244 = SURFACE_CURVE('',#245,(#250,#257),.PCURVE_S1.);
#245 = CIRCLE('',#246,1.7);
#246 = AXIS2_PLACEMENT_3D('',#247,#248,#249);
#247 = CARTESIAN_POINT('',(0.,-22.,1.));
#248 = DIRECTION('',(0.,0.,-1.));
#249 = DIRECTION('',(-1.,0.,0.));
#250 = PCURVE('',#133,#251);
#251 = DEFINITIONAL_REPRESENTATION('',(#252),#256);
#252 = LINE('',#253,#254);
#253 = CARTESIAN_POINT('',(0.,2.));
#254 = VECTOR('',#255,1.);
#255 = DIRECTION('',(1.,0.));
#256 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#257 = PCURVE('',#258,#263);
#258 = PLANE('',#259);
#259 = AXIS2_PLACEMENT_3D('',#260,#261,#262);
#260 = CARTESIAN_POINT('',(0.,0.,1.));
#261 = DIRECTION('',(0.,0.,1.));
#262 = DIRECTION('',(1.,0.,-0.));
#263 = DEFINITIONAL_REPRESENTATION('',(#264),#272);
#264 = ( BOUNDED_CURVE() B_SPLINE_CURVE(2,(#265,#266,#267,#268,#269,#270
,#271),.UNSPECIFIED.,.T.,.F.) B_SPLINE_CURVE_WITH_KNOTS((1,2,2,2,2,1),(
    -2.094,0.,2.094,4.189,6.283,
8.378),.UNSPECIFIED.) CURVE() GEOMETRIC_REPRESENTATION_ITEM() 
RATIONAL_B_SPLINE_CURVE((1.,0.5,1.,0.5,1.,0.5,1.)) REPRESENTATION_ITEM(
  '') );
#265 = CARTESIAN_POINT('',(-1.7,-22.));
#266 = CARTESIAN_POINT('',(-1.7,-19.056));
#267 = CARTESIAN_POINT('',(0.85,-20.528));
#268 = CARTESIAN_POINT('',(3.4,-22.));
#269 = CARTESIAN_POINT('',(0.85,-23.472));
#270 = CARTESIAN_POINT('',(-1.7,-24.944));
#271 = CARTESIAN_POINT('',(-1.7,-22.));
#272 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#278 = VERTEX_POINT('',#279);
#279 = CARTESIAN_POINT('',(-1.7,22.,1.));
#302 = EDGE_CURVE('',#278,#278,#303,.T.);
#303 = SURFACE_CURVE('',#304,(#309,#316),.PCURVE_S1.);
#304 = CIRCLE('',#305,1.7);
#305 = AXIS2_PLACEMENT_3D('',#306,#307,#308);
#306 = CARTESIAN_POINT('',(0.,22.,1.));
#307 = DIRECTION('',(0.,0.,-1.));
#308 = DIRECTION('',(-1.,0.,0.));
#309 = PCURVE('',#168,#310);
#310 = DEFINITIONAL_REPRESENTATION('',(#311),#315);
#311 = LINE('',#312,#313);
#312 = CARTESIAN_POINT('',(0.,2.));
#313 = VECTOR('',#314,1.);
#314 = DIRECTION('',(1.,0.));
#315 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#316 = PCURVE('',#258,#317);
#317 = DEFINITIONAL_REPRESENTATION('',(#318),#326);
#318 = ( BOUNDED_CURVE() B_SPLINE_CURVE(2,(#319,#320,#321,#322,#323,#324
,#325),.UNSPECIFIED.,.T.,.F.) B_SPLINE_CURVE_WITH_KNOTS((1,2,2,2,2,1),(
    -2.094,0.,2.094,4.189,6.283,
8.378),.UNSPECIFIED.) CURVE() GEOMETRIC_REPRESENTATION_ITEM() 
RATIONAL_B_SPLINE_CURVE((1.,0.5,1.,0.5,1.,0.5,1.)) REPRESENTATION_ITEM(
  '') );
#319 = CARTESIAN_POINT('',(-1.7,22.));
#320 = CARTESIAN_POINT('',(-1.7,24.944));
#321 = CARTESIAN_POINT('',(0.85,23.472));
#322 = CARTESIAN_POINT('',(3.4,22.));
#323 = CARTESIAN_POINT('',(0.85,20.528));
#324 = CARTESIAN_POINT('',(-1.7,19.056));
#325 = CARTESIAN_POINT('',(-1.7,22.));
#326 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#332 = VERTEX_POINT('',#333);
#333 = CARTESIAN_POINT('',(25.,0.,1.));
#354 = EDGE_CURVE('',#332,#332,#355,.T.);
#355 = SURFACE_CURVE('',#356,(#361,#368),.PCURVE_S1.);
#356 = CIRCLE('',#357,25.);
#357 = AXIS2_PLACEMENT_3D('',#358,#359,#360);
#358 = CARTESIAN_POINT('',(0.,0.,1.));
#359 = DIRECTION('',(0.,0.,1.));
#360 = DIRECTION('',(1.,0.,0.));
#361 = PCURVE('',#203,#362);
#362 = DEFINITIONAL_REPRESENTATION('',(#363),#367);
#363 = LINE('',#364,#365);
#364 = CARTESIAN_POINT('',(0.,-2.));
#365 = VECTOR('',#366,1.);
#366 = DIRECTION('',(1.,0.));
#367 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#368 = PCURVE('',#258,#369);
#369 = DEFINITIONAL_REPRESENTATION('',(#370),#374);
#370 = CIRCLE('',#371,25.);
#371 = AXIS2_PLACEMENT_2D('',#372,#373);
#372 = CARTESIAN_POINT('',(0.,0.));
#373 = DIRECTION('',(1.,0.));
#374 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#377 = ADVANCED_FACE('',(#378,#381,#384),#258,.T.);
#378 = FACE_BOUND('',#379,.T.);
#379 = EDGE_LOOP('',(#380));
#380 = ORIENTED_EDGE('',*,*,#354,.T.);
#381 = FACE_BOUND('',#382,.T.);
#382 = EDGE_LOOP('',(#383));
#383 = ORIENTED_EDGE('',*,*,#243,.T.);
#384 = FACE_BOUND('',#385,.T.);
#385 = EDGE_LOOP('',(#386));
#386 = ORIENTED_EDGE('',*,*,#302,.T.);
