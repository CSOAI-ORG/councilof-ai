One B-rep face of a CAD part: STEP entity #946.
In plain terms, this planar face has unit normal (0, -1, 0).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#44 = PLANE('',#45);
#45 = AXIS2_PLACEMENT_3D('',#46,#47,#48);
#46 = CARTESIAN_POINT('',(-25.,-7.5,12.5));
#47 = DIRECTION('',(0.,0.,1.));
#48 = DIRECTION('',(1.,0.,0.));
#72 = CYLINDRICAL_SURFACE('',#73,3.);
#73 = AXIS2_PLACEMENT_3D('',#74,#75,#76);
#74 = CARTESIAN_POINT('',(-22.,-4.5,-12.5));
#75 = DIRECTION('',(0.,0.,1.));
#76 = DIRECTION('',(-1.,-0.,0.));
#100 = PLANE('',#101);
#101 = AXIS2_PLACEMENT_3D('',#102,#103,#104);
#102 = CARTESIAN_POINT('',(-25.,-7.5,-12.5));
#103 = DIRECTION('',(0.,0.,1.));
#104 = DIRECTION('',(1.,0.,0.));
#143 = VERTEX_POINT('',#144);
#144 = CARTESIAN_POINT('',(-22.,-7.5,12.5));
#166 = EDGE_CURVE('',#143,#167,#169,.T.);
#167 = VERTEX_POINT('',#168);
#168 = CARTESIAN_POINT('',(22.,-7.5,12.5));
#169 = SURFACE_CURVE('',#170,(#174,#181),.PCURVE_S1.);
#170 = LINE('',#171,#172);
#171 = CARTESIAN_POINT('',(-25.,-7.5,12.5));
#172 = VECTOR('',#173,1.);
#173 = DIRECTION('',(1.,0.,0.));
#174 = PCURVE('',#44,#175);
#175 = DEFINITIONAL_REPRESENTATION('',(#176),#180);
#176 = LINE('',#177,#178);
#177 = CARTESIAN_POINT('',(0.,0.));
#178 = VECTOR('',#179,1.);
#179 = DIRECTION('',(1.,0.));
#180 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#181 = PCURVE('',#182,#187);
#182 = PLANE('',#183);
#183 = AXIS2_PLACEMENT_3D('',#184,#185,#186);
#184 = CARTESIAN_POINT('',(-25.,-7.5,-12.5));
#185 = DIRECTION('',(0.,1.,0.));
#186 = DIRECTION('',(0.,0.,1.));
#187 = DEFINITIONAL_REPRESENTATION('',(#188),#192);
#188 = LINE('',#189,#190);
#189 = CARTESIAN_POINT('',(25.,0.));
#190 = VECTOR('',#191,1.);
#191 = DIRECTION('',(0.,1.));
#192 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#215 = CYLINDRICAL_SURFACE('',#216,3.);
#216 = AXIS2_PLACEMENT_3D('',#217,#218,#219);
#217 = CARTESIAN_POINT('',(22.,-4.5,-12.5));
#218 = DIRECTION('',(0.,0.,1.));
#219 = DIRECTION('',(1.,0.,-0.));
#660 = VERTEX_POINT('',#661);
#661 = CARTESIAN_POINT('',(-22.,-7.5,-12.5));
#683 = EDGE_CURVE('',#660,#143,#684,.T.);
#684 = SURFACE_CURVE('',#685,(#689,#696),.PCURVE_S1.);
#685 = LINE('',#686,#687);
#686 = CARTESIAN_POINT('',(-22.,-7.5,-12.5));
#687 = VECTOR('',#688,1.);
#688 = DIRECTION('',(0.,0.,1.));
#689 = PCURVE('',#72,#690);
#690 = DEFINITIONAL_REPRESENTATION('',(#691),#695);
#691 = LINE('',#692,#693);
#692 = CARTESIAN_POINT('',(1.571,0.));
#693 = VECTOR('',#694,1.);
#694 = DIRECTION('',(0.,1.));
#695 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#696 = PCURVE('',#182,#697);
#697 = DEFINITIONAL_REPRESENTATION('',(#698),#702);
#698 = LINE('',#699,#700);
#699 = CARTESIAN_POINT('',(0.,3.));
#700 = VECTOR('',#701,1.);
#701 = DIRECTION('',(1.,0.));
#702 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#765 = EDGE_CURVE('',#660,#766,#768,.T.);
#766 = VERTEX_POINT('',#767);
#767 = CARTESIAN_POINT('',(22.,-7.5,-12.5));
#768 = SURFACE_CURVE('',#769,(#773,#780),.PCURVE_S1.);
#769 = LINE('',#770,#771);
#770 = CARTESIAN_POINT('',(-25.,-7.5,-12.5));
#771 = VECTOR('',#772,1.);
#772 = DIRECTION('',(1.,0.,0.));
#773 = PCURVE('',#100,#774);
#774 = DEFINITIONAL_REPRESENTATION('',(#775),#779);
#775 = LINE('',#776,#777);
#776 = CARTESIAN_POINT('',(0.,0.));
#777 = VECTOR('',#778,1.);
#778 = DIRECTION('',(1.,0.));
#779 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#780 = PCURVE('',#182,#781);
#781 = DEFINITIONAL_REPRESENTATION('',(#782),#786);
#782 = LINE('',#783,#784);
#783 = CARTESIAN_POINT('',(0.,0.));
#784 = VECTOR('',#785,1.);
#785 = DIRECTION('',(0.,1.));
#786 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#946 = ADVANCED_FACE('',(#947),#182,.F.);
#947 = FACE_BOUND('',#948,.F.);
#948 = EDGE_LOOP('',(#949,#950,#951,#952));
#949 = ORIENTED_EDGE('',*,*,#765,.F.);
#950 = ORIENTED_EDGE('',*,*,#683,.T.);
#951 = ORIENTED_EDGE('',*,*,#166,.T.);
#952 = ORIENTED_EDGE('',*,*,#953,.F.);
#953 = EDGE_CURVE('',#766,#167,#954,.T.);
#954 = SURFACE_CURVE('',#955,(#959,#966),.PCURVE_S1.);
#955 = LINE('',#956,#957);
#956 = CARTESIAN_POINT('',(22.,-7.5,-12.5));
#957 = VECTOR('',#958,1.);
#958 = DIRECTION('',(0.,0.,1.));
#959 = PCURVE('',#182,#960);
#960 = DEFINITIONAL_REPRESENTATION('',(#961),#965);
#961 = LINE('',#962,#963);
#962 = CARTESIAN_POINT('',(0.,47.));
#963 = VECTOR('',#964,1.);
#964 = DIRECTION('',(1.,0.));
#965 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#966 = PCURVE('',#215,#967);
#967 = DEFINITIONAL_REPRESENTATION('',(#968),#972);
#968 = LINE('',#969,#970);
#969 = CARTESIAN_POINT('',(-1.571,0.));
#970 = VECTOR('',#971,1.);
#971 = DIRECTION('',(-0.,1.));
#972 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
