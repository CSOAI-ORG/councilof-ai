STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:45',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 10
Bounding box: 250 x 80 x 30 mm (x, y, z)
Volume: 398405.9 mm3; surface area: 70190.7 mm2
Topology: 1 solids, 1 shells, 23 faces, 48 edges, 32 vertices
Faces by surface type: plane 15, cylinder 8
Full cylindrical faces by diameter (mm): 5.5 x4
Entity records: 1264 total; most frequent: CARTESIAN_POINT 224, DIRECTION 204, LINE 112, VECTOR 112, ORIENTED_EDGE 96, PCURVE 96, DEFINITIONAL_REPRESENTATION 96, EDGE_CURVE 48
