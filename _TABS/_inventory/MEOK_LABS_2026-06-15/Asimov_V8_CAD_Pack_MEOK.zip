STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:29',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 28
Bounding box: 80 x 50 x 10 mm (x, y, z)
Volume: 20542 mm3; surface area: 10021 mm2
Topology: 1 solids, 1 shells, 30 faces, 64 edges, 40 vertices
Faces by surface type: plane 14, cylinder 12, cone 4
Full cylindrical faces by diameter (mm): 3.4 x4, 8 x4
Entity records: 1696 total; most frequent: CARTESIAN_POINT 363, DIRECTION 252, ORIENTED_EDGE 128, PCURVE 128, DEFINITIONAL_REPRESENTATION 128, LINE 124, VECTOR 124, EDGE_CURVE 64
