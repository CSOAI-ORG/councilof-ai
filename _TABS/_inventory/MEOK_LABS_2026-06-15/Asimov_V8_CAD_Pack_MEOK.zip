One B-rep face of a CAD part: STEP entity #17.
In plain terms, this planar face has unit normal (-1, 0, 0).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#17 = ADVANCED_FACE('',(#18),#32,.F.);
#18 = FACE_BOUND('',#19,.F.);
#19 = EDGE_LOOP('',(#20,#55,#83,#111,#139,#167,#195,#223,#251,#279));
#20 = ORIENTED_EDGE('',*,*,#21,.F.);
#21 = EDGE_CURVE('',#22,#24,#26,.T.);
#22 = VERTEX_POINT('',#23);
#23 = CARTESIAN_POINT('',(-70.,-19.,5.));
#24 = VERTEX_POINT('',#25);
#25 = CARTESIAN_POINT('',(-70.,19.,5.));
#26 = SURFACE_CURVE('',#27,(#31,#43),.PCURVE_S1.);
#27 = LINE('',#28,#29);
#28 = CARTESIAN_POINT('',(-70.,-25.,5.));
#29 = VECTOR('',#30,1.);
#30 = DIRECTION('',(0.,1.,0.));
#31 = PCURVE('',#32,#37);
#32 = PLANE('',#33);
#33 = AXIS2_PLACEMENT_3D('',#34,#35,#36);
#34 = CARTESIAN_POINT('',(-70.,-25.,-5.));
#35 = DIRECTION('',(1.,0.,0.));
#36 = DIRECTION('',(0.,0.,1.));
#37 = DEFINITIONAL_REPRESENTATION('',(#38),#42);
#38 = LINE('',#39,#40);
#39 = CARTESIAN_POINT('',(10.,0.));
#40 = VECTOR('',#41,1.);
#41 = DIRECTION('',(0.,-1.));
#42 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#43 = PCURVE('',#44,#49);
#44 = PLANE('',#45);
#45 = AXIS2_PLACEMENT_3D('',#46,#47,#48);
#46 = CARTESIAN_POINT('',(-70.,-25.,5.));
#47 = DIRECTION('',(0.,0.,1.));
#48 = DIRECTION('',(1.,0.,0.));
#49 = DEFINITIONAL_REPRESENTATION('',(#50),#54);
#50 = LINE('',#51,#52);
#51 = CARTESIAN_POINT('',(0.,0.));
#52 = VECTOR('',#53,1.);
#53 = DIRECTION('',(0.,1.));
#54 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#55 = ORIENTED_EDGE('',*,*,#56,.T.);
#56 = EDGE_CURVE('',#22,#57,#59,.T.);
#57 = VERTEX_POINT('',#58);
#58 = CARTESIAN_POINT('',(-70.,-19.,60.));
#59 = SURFACE_CURVE('',#60,(#64,#71),.PCURVE_S1.);
#60 = LINE('',#61,#62);
#61 = CARTESIAN_POINT('',(-70.,-19.,5.));
#62 = VECTOR('',#63,1.);
#63 = DIRECTION('',(0.,0.,1.));
#64 = PCURVE('',#32,#65);
#65 = DEFINITIONAL_REPRESENTATION('',(#66),#70);
#66 = LINE('',#67,#68);
#67 = CARTESIAN_POINT('',(10.,-6.));
#68 = VECTOR('',#69,1.);
#69 = DIRECTION('',(1.,0.));
#70 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#71 = PCURVE('',#72,#77);
#72 = PLANE('',#73);
#73 = AXIS2_PLACEMENT_3D('',#74,#75,#76);
#74 = CARTESIAN_POINT('',(-60.,-19.,5.));
#75 = DIRECTION('',(0.,-1.,0.));
#76 = DIRECTION('',(-1.,0.,0.));
#77 = DEFINITIONAL_REPRESENTATION('',(#78),#82);
#78 = LINE('',#79,#80);
#79 = CARTESIAN_POINT('',(10.,0.));
#80 = VECTOR('',#81,1.);
#81 = DIRECTION('',(0.,-1.));
#82 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#83 = ORIENTED_EDGE('',*,*,#84,.T.);
#84 = EDGE_CURVE('',#57,#85,#87,.T.);
#85 = VERTEX_POINT('',#86);
#86 = CARTESIAN_POINT('',(-70.,-21.,60.));
#87 = SURFACE_CURVE('',#88,(#92,#99),.PCURVE_S1.);
#88 = LINE('',#89,#90);
#89 = CARTESIAN_POINT('',(-70.,-19.,60.));
#90 = VECTOR('',#91,1.);
#91 = DIRECTION('',(0.,-1.,0.));
#92 = PCURVE('',#32,#93);
#93 = DEFINITIONAL_REPRESENTATION('',(#94),#98);
#94 = LINE('',#95,#96);
#95 = CARTESIAN_POINT('',(65.,-6.));
#96 = VECTOR('',#97,1.);
#97 = DIRECTION('',(0.,1.));
#98 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#99 = PCURVE('',#100,#105);
#100 = PLANE('',#101);
#101 = AXIS2_PLACEMENT_3D('',#102,#103,#104);
#102 = CARTESIAN_POINT('',(-65.,-20.,60.));
#103 = DIRECTION('',(0.,0.,1.));
#104 = DIRECTION('',(1.,0.,-0.));
#105 = DEFINITIONAL_REPRESENTATION('',(#106),#110);
#106 = LINE('',#107,#108);
#107 = CARTESIAN_POINT('',(-5.,1.));
#108 = VECTOR('',#109,1.);
#109 = DIRECTION('',(0.,-1.));
#110 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#111 = ORIENTED_EDGE('',*,*,#112,.F.);
#112 = EDGE_CURVE('',#113,#85,#115,.T.);
#113 = VERTEX_POINT('',#114);
#114 = CARTESIAN_POINT('',(-70.,-21.,5.));
#115 = SURFACE_CURVE('',#116,(#120,#127),.PCURVE_S1.);
#116 = LINE('',#117,#118);
#117 = CARTESIAN_POINT('',(-70.,-21.,5.));
#118 = VECTOR('',#119,1.);
#119 = DIRECTION('',(0.,0.,1.));
#120 = PCURVE('',#32,#121);
#121 = DEFINITIONAL_REPRESENTATION('',(#122),#126);
#122 = LINE('',#123,#124);
#123 = CARTESIAN_POINT('',(10.,-4.));
#124 = VECTOR('',#125,1.);
#125 = DIRECTION('',(1.,0.));
#126 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#127 = PCURVE('',#128,#133);
#128 = PLANE('',#129);
#129 = AXIS2_PLACEMENT_3D('',#130,#131,#132);
#130 = CARTESIAN_POINT('',(-70.,-21.,5.));
#131 = DIRECTION('',(0.,1.,0.));
#132 = DIRECTION('',(1.,0.,0.));
#133 = DEFINITIONAL_REPRESENTATION('',(#134),#138);
#134 = LINE('',#135,#136);
#135 = CARTESIAN_POINT('',(0.,0.));
#136 = VECTOR('',#137,1.);
#137 = DIRECTION('',(0.,-1.));
#138 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#139 = ORIENTED_EDGE('',*,*,#140,.F.);
#140 = EDGE_CURVE('',#141,#113,#143,.T.);
#141 = VERTEX_POINT('',#142);
#142 = CARTESIAN_POINT('',(-70.,-21.,-5.));
#143 = SURFACE_CURVE('',#144,(#148,#155),.PCURVE_S1.);
#144 = LINE('',#145,#146);
#145 = CARTESIAN_POINT('',(-70.,-21.,-5.));
#146 = VECTOR('',#147,1.);
#147 = DIRECTION('',(0.,0.,1.));
#148 = PCURVE('',#32,#149);
#149 = DEFINITIONAL_REPRESENTATION('',(#150),#154);
#150 = LINE('',#151,#152);
#151 = CARTESIAN_POINT('',(0.,-4.));
#152 = VECTOR('',#153,1.);
#153 = DIRECTION('',(1.,0.));
#154 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#155 = PCURVE('',#156,#161);
#156 = CYLINDRICAL_SURFACE('',#157,4.);
#157 = AXIS2_PLACEMENT_3D('',#158,#159,#160);
#158 = CARTESIAN_POINT('',(-66.,-21.,-5.));
#159 = DIRECTION('',(0.,0.,1.));
#160 = DIRECTION('',(-1.,-0.,0.));
#161 = DEFINITIONAL_REPRESENTATION('',(#162),#166);
#162 = LINE('',#163,#164);
#163 = CARTESIAN_POINT('',(0.,0.));
#164 = VECTOR('',#165,1.);
#165 = DIRECTION('',(0.,1.));
#166 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#167 = ORIENTED_EDGE('',*,*,#168,.T.);
#168 = EDGE_CURVE('',#141,#169,#171,.T.);
#169 = VERTEX_POINT('',#170);
#170 = CARTESIAN_POINT('',(-70.,21.,-5.));
#171 = SURFACE_CURVE('',#172,(#176,#183),.PCURVE_S1.);
#172 = LINE('',#173,#174);
#173 = CARTESIAN_POINT('',(-70.,-25.,-5.));
#174 = VECTOR('',#175,1.);
#175 = DIRECTION('',(0.,1.,0.));
#176 = PCURVE('',#32,#177);
#177 = DEFINITIONAL_REPRESENTATION('',(#178),#182);
#178 = LINE('',#179,#180);
#179 = CARTESIAN_POINT('',(0.,0.));
#180 = VECTOR('',#181,1.);
#181 = DIRECTION('',(0.,-1.));
#182 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#183 = PCURVE('',#184,#189);
#184 = PLANE('',#185);
#185 = AXIS2_PLACEMENT_3D('',#186,#187,#188);
#186 = CARTESIAN_POINT('',(-70.,-25.,-5.));
#187 = DIRECTION('',(0.,0.,1.));
#188 = DIRECTION('',(1.,0.,0.));
#189 = DEFINITIONAL_REPRESENTATION('',(#190),#194);
#190 = LINE('',#191,#192);
#191 = CARTESIAN_POINT('',(0.,0.));
#192 = VECTOR('',#193,1.);
#193 = DIRECTION('',(0.,1.));
#194 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#195 = ORIENTED_EDGE('',*,*,#196,.T.);
#196 = EDGE_CURVE('',#169,#197,#199,.T.);
#197 = VERTEX_POINT('',#198);
#198 = CARTESIAN_POINT('',(-70.,21.,5.));
#199 = SURFACE_CURVE('',#200,(#204,#211),.PCURVE_S1.);
#200 = LINE('',#201,#202);
#201 = CARTESIAN_POINT('',(-70.,21.,-5.));
#202 = VECTOR('',#203,1.);
#203 = DIRECTION('',(0.,0.,1.));
#204 = PCURVE('',#32,#205);
#205 = DEFINITIONAL_REPRESENTATION('',(#206),#210);
#206 = LINE('',#207,#208);
#207 = CARTESIAN_POINT('',(0.,-46.));
#208 = VECTOR('',#209,1.);
#209 = DIRECTION('',(1.,0.));
#210 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#211 = PCURVE('',#212,#217);
#212 = CYLINDRICAL_SURFACE('',#213,4.);
#213 = AXIS2_PLACEMENT_3D('',#214,#215,#216);
#214 = CARTESIAN_POINT('',(-66.,21.,-5.));
#215 = DIRECTION('',(0.,0.,1.));
#216 = DIRECTION('',(-1.,-0.,0.));
#217 = DEFINITIONAL_REPRESENTATION('',(#218),#222);
#218 = LINE('',#219,#220);
#219 = CARTESIAN_POINT('',(-0.,0.));
#220 = VECTOR('',#221,1.);
#221 = DIRECTION('',(-0.,1.));
#222 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#223 = ORIENTED_EDGE('',*,*,#224,.T.);
#224 = EDGE_CURVE('',#197,#225,#227,.T.);
#225 = VERTEX_POINT('',#226);
#226 = CARTESIAN_POINT('',(-70.,21.,60.));
#227 = SURFACE_CURVE('',#228,(#232,#239),.PCURVE_S1.);
#228 = LINE('',#229,#230);
#229 = CARTESIAN_POINT('',(-70.,21.,5.));
#230 = VECTOR('',#231,1.);
#231 = DIRECTION('',(0.,0.,1.));
#232 = PCURVE('',#32,#233);
#233 = DEFINITIONAL_REPRESENTATION('',(#234),#238);
#234 = LINE('',#235,#236);
#235 = CARTESIAN_POINT('',(10.,-46.));
#236 = VECTOR('',#237,1.);
#237 = DIRECTION('',(1.,0.));
#238 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#239 = PCURVE('',#240,#245);
#240 = PLANE('',#241);
#241 = AXIS2_PLACEMENT_3D('',#242,#243,#244);
#242 = CARTESIAN_POINT('',(-60.,21.,5.));
#243 = DIRECTION('',(0.,-1.,0.));
#244 = DIRECTION('',(-1.,0.,0.));
#245 = DEFINITIONAL_REPRESENTATION('',(#246),#250);
#246 = LINE('',#247,#248);
#247 = CARTESIAN_POINT('',(10.,0.));
#248 = VECTOR('',#249,1.);
#249 = DIRECTION('',(0.,-1.));
#250 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#251 = ORIENTED_EDGE('',*,*,#252,.T.);
#252 = EDGE_CURVE('',#225,#253,#255,.T.);
#253 = VERTEX_POINT('',#254);
#254 = CARTESIAN_POINT('',(-70.,19.,60.));
#255 = SURFACE_CURVE('',#256,(#260,#267),.PCURVE_S1.);
#256 = LINE('',#257,#258);
#257 = CARTESIAN_POINT('',(-70.,21.,60.));
#258 = VECTOR('',#259,1.);
#259 = DIRECTION('',(0.,-1.,0.));
#260 = PCURVE('',#32,#261);
#261 = DEFINITIONAL_REPRESENTATION('',(#262),#266);
#262 = LINE('',#263,#264);
#263 = CARTESIAN_POINT('',(65.,-46.));
#264 = VECTOR('',#265,1.);
#265 = DIRECTION('',(0.,1.));
#266 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#267 = PCURVE('',#268,#273);
#268 = PLANE('',#269);
#269 = AXIS2_PLACEMENT_3D('',#270,#271,#272);
#270 = CARTESIAN_POINT('',(-65.,-20.,60.));
#271 = DIRECTION('',(0.,0.,1.));
#272 = DIRECTION('',(1.,0.,-0.));
#273 = DEFINITIONAL_REPRESENTATION('',(#274),#278);
#274 = LINE('',#275,#276);
#275 = CARTESIAN_POINT('',(-5.,41.));
#276 = VECTOR('',#277,1.);
#277 = DIRECTION('',(0.,-1.));
#278 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#279 = ORIENTED_EDGE('',*,*,#280,.F.);
#280 = EDGE_CURVE('',#24,#253,#281,.T.);
#281 = SURFACE_CURVE('',#282,(#286,#293),.PCURVE_S1.);
#282 = LINE('',#283,#284);
#283 = CARTESIAN_POINT('',(-70.,19.,5.));
#284 = VECTOR('',#285,1.);
#285 = DIRECTION('',(0.,0.,1.));
#286 = PCURVE('',#32,#287);
#287 = DEFINITIONAL_REPRESENTATION('',(#288),#292);
#288 = LINE('',#289,#290);
#289 = CARTESIAN_POINT('',(10.,-44.));
#290 = VECTOR('',#291,1.);
#291 = DIRECTION('',(1.,0.));
#292 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#293 = PCURVE('',#294,#299);
#294 = PLANE('',#295);
#295 = AXIS2_PLACEMENT_3D('',#296,#297,#298);
#296 = CARTESIAN_POINT('',(-70.,19.,5.));
#297 = DIRECTION('',(0.,1.,0.));
#298 = DIRECTION('',(1.,0.,0.));
#299 = DEFINITIONAL_REPRESENTATION('',(#300),#304);
#300 = LINE('',#301,#302);
#301 = CARTESIAN_POINT('',(0.,0.));
#302 = VECTOR('',#303,1.);
#303 = DIRECTION('',(0.,-1.));
#304 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
