STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:30:43',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 3
Bounding box: 12 x 50 x 6 mm (x, y, z)
Volume: 3081.3 mm3; surface area: 2032.8 mm2
Topology: 1 solids, 1 shells, 21 faces, 49 edges, 30 vertices
Faces by surface type: plane 10, cylinder 7, cone 4
Full cylindrical faces by diameter (mm): 4.2 x2, 8.2 x1
Entity records: 1276 total; most frequent: CARTESIAN_POINT 287, DIRECTION 181, LINE 99, VECTOR 99, ORIENTED_EDGE 98, PCURVE 98, DEFINITIONAL_REPRESENTATION 98, EDGE_CURVE 49
