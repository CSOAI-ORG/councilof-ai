One B-rep face of a CAD part: STEP entity #996.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#358 = PLANE('',#359);
#359 = AXIS2_PLACEMENT_3D('',#360,#361,#362);
#360 = CARTESIAN_POINT('',(17.,-9.,6.));
#361 = DIRECTION('',(1.,0.,0.));
#362 = DIRECTION('',(-0.,1.,0.));
#386 = PLANE('',#387);
#387 = AXIS2_PLACEMENT_3D('',#388,#389,#390);
#388 = CARTESIAN_POINT('',(-17.,-9.,6.));
#389 = DIRECTION('',(0.,-1.,0.));
#390 = DIRECTION('',(1.,0.,0.));
#414 = PLANE('',#415);
#415 = AXIS2_PLACEMENT_3D('',#416,#417,#418);
#416 = CARTESIAN_POINT('',(-17.,9.,6.));
#417 = DIRECTION('',(-1.,0.,0.));
#418 = DIRECTION('',(0.,-1.,0.));
#440 = PLANE('',#441);
#441 = AXIS2_PLACEMENT_3D('',#442,#443,#444);
#442 = CARTESIAN_POINT('',(17.,9.,6.));
#443 = DIRECTION('',(0.,1.,-0.));
#444 = DIRECTION('',(-1.,0.,0.));
#800 = VERTEX_POINT('',#801);
#801 = CARTESIAN_POINT('',(-17.,-9.,-2.));
#822 = EDGE_CURVE('',#800,#823,#825,.T.);
#823 = VERTEX_POINT('',#824);
#824 = CARTESIAN_POINT('',(17.,-9.,-2.));
#825 = SURFACE_CURVE('',#826,(#830,#837),.PCURVE_S1.);
#826 = LINE('',#827,#828);
#827 = CARTESIAN_POINT('',(-17.,-9.,-2.));
#828 = VECTOR('',#829,1.);
#829 = DIRECTION('',(1.,0.,0.));
#830 = PCURVE('',#386,#831);
#831 = DEFINITIONAL_REPRESENTATION('',(#832),#836);
#832 = LINE('',#833,#834);
#833 = CARTESIAN_POINT('',(0.,-8.));
#834 = VECTOR('',#835,1.);
#835 = DIRECTION('',(1.,0.));
#836 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#837 = PCURVE('',#838,#843);
#838 = PLANE('',#839);
#839 = AXIS2_PLACEMENT_3D('',#840,#841,#842);
#840 = CARTESIAN_POINT('',(0.,0.,-2.));
#841 = DIRECTION('',(0.,0.,1.));
#842 = DIRECTION('',(1.,0.,-0.));
#843 = DEFINITIONAL_REPRESENTATION('',(#844),#848);
#844 = LINE('',#845,#846);
#845 = CARTESIAN_POINT('',(-17.,-9.));
#846 = VECTOR('',#847,1.);
#847 = DIRECTION('',(1.,0.));
#848 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#876 = EDGE_CURVE('',#823,#877,#879,.T.);
#877 = VERTEX_POINT('',#878);
#878 = CARTESIAN_POINT('',(17.,9.,-2.));
#879 = SURFACE_CURVE('',#880,(#884,#891),.PCURVE_S1.);
#880 = LINE('',#881,#882);
#881 = CARTESIAN_POINT('',(17.,-9.,-2.));
#882 = VECTOR('',#883,1.);
#883 = DIRECTION('',(0.,1.,0.));
#884 = PCURVE('',#358,#885);
#885 = DEFINITIONAL_REPRESENTATION('',(#886),#890);
#886 = LINE('',#887,#888);
#887 = CARTESIAN_POINT('',(0.,-8.));
#888 = VECTOR('',#889,1.);
#889 = DIRECTION('',(1.,0.));
#890 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#891 = PCURVE('',#838,#892);
#892 = DEFINITIONAL_REPRESENTATION('',(#893),#897);
#893 = LINE('',#894,#895);
#894 = CARTESIAN_POINT('',(17.,-9.));
#895 = VECTOR('',#896,1.);
#896 = DIRECTION('',(0.,1.));
#897 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#925 = EDGE_CURVE('',#877,#926,#928,.T.);
#926 = VERTEX_POINT('',#927);
#927 = CARTESIAN_POINT('',(-17.,9.,-2.));
#928 = SURFACE_CURVE('',#929,(#933,#940),.PCURVE_S1.);
#929 = LINE('',#930,#931);
#930 = CARTESIAN_POINT('',(17.,9.,-2.));
#931 = VECTOR('',#932,1.);
#932 = DIRECTION('',(-1.,0.,0.));
#933 = PCURVE('',#440,#934);
#934 = DEFINITIONAL_REPRESENTATION('',(#935),#939);
#935 = LINE('',#936,#937);
#936 = CARTESIAN_POINT('',(0.,-8.));
#937 = VECTOR('',#938,1.);
#938 = DIRECTION('',(1.,0.));
#939 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#940 = PCURVE('',#838,#941);
#941 = DEFINITIONAL_REPRESENTATION('',(#942),#946);
#942 = LINE('',#943,#944);
#943 = CARTESIAN_POINT('',(17.,9.));
#944 = VECTOR('',#945,1.);
#945 = DIRECTION('',(-1.,0.));
#946 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#974 = EDGE_CURVE('',#926,#800,#975,.T.);
#975 = SURFACE_CURVE('',#976,(#980,#987),.PCURVE_S1.);
#976 = LINE('',#977,#978);
#977 = CARTESIAN_POINT('',(-17.,9.,-2.));
#978 = VECTOR('',#979,1.);
#979 = DIRECTION('',(0.,-1.,0.));
#980 = PCURVE('',#414,#981);
#981 = DEFINITIONAL_REPRESENTATION('',(#982),#986);
#982 = LINE('',#983,#984);
#983 = CARTESIAN_POINT('',(0.,-8.));
#984 = VECTOR('',#985,1.);
#985 = DIRECTION('',(1.,0.));
#986 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#987 = PCURVE('',#838,#988);
#988 = DEFINITIONAL_REPRESENTATION('',(#989),#993);
#989 = LINE('',#990,#991);
#990 = CARTESIAN_POINT('',(-17.,9.));
#991 = VECTOR('',#992,1.);
#992 = DIRECTION('',(0.,-1.));
#993 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#996 = ADVANCED_FACE('',(#997),#838,.T.);
#997 = FACE_BOUND('',#998,.T.);
#998 = EDGE_LOOP('',(#999,#1000,#1001,#1002));
#999 = ORIENTED_EDGE('',*,*,#822,.T.);
#1000 = ORIENTED_EDGE('',*,*,#876,.T.);
#1001 = ORIENTED_EDGE('',*,*,#925,.T.);
#1002 = ORIENTED_EDGE('',*,*,#974,.T.);
