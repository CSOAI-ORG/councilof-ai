One B-rep face of a CAD part: STEP entity #1974.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#465 = PLANE('',#466);
#466 = AXIS2_PLACEMENT_3D('',#467,#468,#469);
#467 = CARTESIAN_POINT('',(-16.,-10.,7.));
#468 = DIRECTION('',(0.,-1.,0.));
#469 = DIRECTION('',(1.,0.,0.));
#493 = PLANE('',#494);
#494 = AXIS2_PLACEMENT_3D('',#495,#496,#497);
#495 = CARTESIAN_POINT('',(-16.,10.,7.));
#496 = DIRECTION('',(-1.,0.,0.));
#497 = DIRECTION('',(0.,-1.,0.));
#521 = PLANE('',#522);
#522 = AXIS2_PLACEMENT_3D('',#523,#524,#525);
#523 = CARTESIAN_POINT('',(16.,10.,7.));
#524 = DIRECTION('',(0.,1.,-0.));
#525 = DIRECTION('',(-1.,0.,0.));
#547 = PLANE('',#548);
#548 = AXIS2_PLACEMENT_3D('',#549,#550,#551);
#549 = CARTESIAN_POINT('',(16.,-10.,7.));
#550 = DIRECTION('',(1.,0.,0.));
#551 = DIRECTION('',(-0.,1.,0.));
#1203 = CYLINDRICAL_SURFACE('',#1204,1.7);
#1204 = AXIS2_PLACEMENT_3D('',#1205,#1206,#1207);
#1205 = CARTESIAN_POINT('',(-14.,0.,-7.));
#1206 = DIRECTION('',(0.,0.,1.));
#1207 = DIRECTION('',(-1.,0.,0.));
#1461 = VERTEX_POINT('',#1462);
#1462 = CARTESIAN_POINT('',(-16.,-10.,-3.));
#1483 = EDGE_CURVE('',#1461,#1484,#1486,.T.);
#1484 = VERTEX_POINT('',#1485);
#1485 = CARTESIAN_POINT('',(16.,-10.,-3.));
#1486 = SURFACE_CURVE('',#1487,(#1491,#1498),.PCURVE_S1.);
#1487 = LINE('',#1488,#1489);
#1488 = CARTESIAN_POINT('',(-16.,-10.,-3.));
#1489 = VECTOR('',#1490,1.);
#1490 = DIRECTION('',(1.,0.,0.));
#1491 = PCURVE('',#465,#1492);
#1492 = DEFINITIONAL_REPRESENTATION('',(#1493),#1497);
#1493 = LINE('',#1494,#1495);
#1494 = CARTESIAN_POINT('',(0.,-10.));
#1495 = VECTOR('',#1496,1.);
#1496 = DIRECTION('',(1.,0.));
#1497 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1498 = PCURVE('',#1499,#1504);
#1499 = PLANE('',#1500);
#1500 = AXIS2_PLACEMENT_3D('',#1501,#1502,#1503);
#1501 = CARTESIAN_POINT('',(0.,0.,-3.));
#1502 = DIRECTION('',(0.,0.,1.));
#1503 = DIRECTION('',(1.,0.,-0.));
#1504 = DEFINITIONAL_REPRESENTATION('',(#1505),#1509);
#1505 = LINE('',#1506,#1507);
#1506 = CARTESIAN_POINT('',(-16.,-10.));
#1507 = VECTOR('',#1508,1.);
#1508 = DIRECTION('',(1.,0.));
#1509 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1537 = EDGE_CURVE('',#1484,#1538,#1540,.T.);
#1538 = VERTEX_POINT('',#1539);
#1539 = CARTESIAN_POINT('',(16.,10.,-3.));
#1540 = SURFACE_CURVE('',#1541,(#1545,#1552),.PCURVE_S1.);
#1541 = LINE('',#1542,#1543);
#1542 = CARTESIAN_POINT('',(16.,-10.,-3.));
#1543 = VECTOR('',#1544,1.);
#1544 = DIRECTION('',(0.,1.,0.));
#1545 = PCURVE('',#547,#1546);
#1546 = DEFINITIONAL_REPRESENTATION('',(#1547),#1551);
#1547 = LINE('',#1548,#1549);
#1548 = CARTESIAN_POINT('',(0.,-10.));
#1549 = VECTOR('',#1550,1.);
#1550 = DIRECTION('',(1.,0.));
#1551 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1552 = PCURVE('',#1499,#1553);
#1553 = DEFINITIONAL_REPRESENTATION('',(#1554),#1558);
#1554 = LINE('',#1555,#1556);
#1555 = CARTESIAN_POINT('',(16.,-10.));
#1556 = VECTOR('',#1557,1.);
#1557 = DIRECTION('',(0.,1.));
#1558 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1586 = EDGE_CURVE('',#1538,#1587,#1589,.T.);
#1587 = VERTEX_POINT('',#1588);
#1588 = CARTESIAN_POINT('',(-16.,10.,-3.));
#1589 = SURFACE_CURVE('',#1590,(#1594,#1601),.PCURVE_S1.);
#1590 = LINE('',#1591,#1592);
#1591 = CARTESIAN_POINT('',(16.,10.,-3.));
#1592 = VECTOR('',#1593,1.);
#1593 = DIRECTION('',(-1.,0.,0.));
#1594 = PCURVE('',#521,#1595);
#1595 = DEFINITIONAL_REPRESENTATION('',(#1596),#1600);
#1596 = LINE('',#1597,#1598);
#1597 = CARTESIAN_POINT('',(0.,-10.));
#1598 = VECTOR('',#1599,1.);
#1599 = DIRECTION('',(1.,0.));
#1600 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1601 = PCURVE('',#1499,#1602);
#1602 = DEFINITIONAL_REPRESENTATION('',(#1603),#1607);
#1603 = LINE('',#1604,#1605);
#1604 = CARTESIAN_POINT('',(16.,10.));
#1605 = VECTOR('',#1606,1.);
#1606 = DIRECTION('',(-1.,0.));
#1607 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1635 = EDGE_CURVE('',#1587,#1461,#1636,.T.);
#1636 = SURFACE_CURVE('',#1637,(#1641,#1648),.PCURVE_S1.);
#1637 = LINE('',#1638,#1639);
#1638 = CARTESIAN_POINT('',(-16.,10.,-3.));
#1639 = VECTOR('',#1640,1.);
#1640 = DIRECTION('',(0.,-1.,0.));
#1641 = PCURVE('',#493,#1642);
#1642 = DEFINITIONAL_REPRESENTATION('',(#1643),#1647);
#1643 = LINE('',#1644,#1645);
#1644 = CARTESIAN_POINT('',(0.,-10.));
#1645 = VECTOR('',#1646,1.);
#1646 = DIRECTION('',(1.,0.));
#1647 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1648 = PCURVE('',#1499,#1649);
#1649 = DEFINITIONAL_REPRESENTATION('',(#1650),#1654);
#1650 = LINE('',#1651,#1652);
#1651 = CARTESIAN_POINT('',(-16.,10.));
#1652 = VECTOR('',#1653,1.);
#1653 = DIRECTION('',(0.,-1.));
#1654 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1963 = CYLINDRICAL_SURFACE('',#1964,1.7);
#1964 = AXIS2_PLACEMENT_3D('',#1965,#1966,#1967);
#1965 = CARTESIAN_POINT('',(14.,0.,-7.));
#1966 = DIRECTION('',(0.,0.,1.));
#1967 = DIRECTION('',(-1.,0.,0.));
#1974 = ADVANCED_FACE('',(#1975,#1981,#2007),#1499,.T.);
#1975 = FACE_BOUND('',#1976,.T.);
#1976 = EDGE_LOOP('',(#1977,#1978,#1979,#1980));
#1977 = ORIENTED_EDGE('',*,*,#1483,.T.);
#1978 = ORIENTED_EDGE('',*,*,#1537,.T.);
#1979 = ORIENTED_EDGE('',*,*,#1586,.T.);
#1980 = ORIENTED_EDGE('',*,*,#1635,.T.);
#1981 = FACE_BOUND('',#1982,.T.);
#1982 = EDGE_LOOP('',(#1983));
#1983 = ORIENTED_EDGE('',*,*,#1984,.F.);
#1984 = EDGE_CURVE('',#1985,#1985,#1987,.T.);
#1985 = VERTEX_POINT('',#1986);
#1986 = CARTESIAN_POINT('',(-15.7,0.,-3.));
#1987 = SURFACE_CURVE('',#1988,(#1993,#2000),.PCURVE_S1.);
#1988 = CIRCLE('',#1989,1.7);
#1989 = AXIS2_PLACEMENT_3D('',#1990,#1991,#1992);
#1990 = CARTESIAN_POINT('',(-14.,0.,-3.));
#1991 = DIRECTION('',(0.,0.,1.));
#1992 = DIRECTION('',(-1.,0.,0.));
#1993 = PCURVE('',#1499,#1994);
#1994 = DEFINITIONAL_REPRESENTATION('',(#1995),#1999);
#1995 = CIRCLE('',#1996,1.7);
#1996 = AXIS2_PLACEMENT_2D('',#1997,#1998);
#1997 = CARTESIAN_POINT('',(-14.,0.));
#1998 = DIRECTION('',(-1.,0.));
#1999 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#2000 = PCURVE('',#1203,#2001);
#2001 = DEFINITIONAL_REPRESENTATION('',(#2002),#2006);
#2002 = LINE('',#2003,#2004);
#2003 = CARTESIAN_POINT('',(0.,4.));
#2004 = VECTOR('',#2005,1.);
#2005 = DIRECTION('',(1.,0.));
#2006 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#2007 = FACE_BOUND('',#2008,.T.);
#2008 = EDGE_LOOP('',(#2009));
#2009 = ORIENTED_EDGE('',*,*,#2010,.F.);
#2010 = EDGE_CURVE('',#2011,#2011,#2013,.T.);
#2011 = VERTEX_POINT('',#2012);
#2012 = CARTESIAN_POINT('',(12.3,0.,-3.));
#2013 = SURFACE_CURVE('',#2014,(#2019,#2026),.PCURVE_S1.);
#2014 = CIRCLE('',#2015,1.7);
#2015 = AXIS2_PLACEMENT_3D('',#2016,#2017,#2018);
#2016 = CARTESIAN_POINT('',(14.,0.,-3.));
#2017 = DIRECTION('',(0.,0.,1.));
#2018 = DIRECTION('',(-1.,0.,0.));
#2019 = PCURVE('',#1499,#2020);
#2020 = DEFINITIONAL_REPRESENTATION('',(#2021),#2025);
#2021 = CIRCLE('',#2022,1.7);
#2022 = AXIS2_PLACEMENT_2D('',#2023,#2024);
#2023 = CARTESIAN_POINT('',(14.,0.));
#2024 = DIRECTION('',(-1.,0.));
#2025 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#2026 = PCURVE('',#1963,#2027);
#2027 = DEFINITIONAL_REPRESENTATION('',(#2028),#2032);
#2028 = LINE('',#2029,#2030);
#2029 = CARTESIAN_POINT('',(0.,4.));
#2030 = VECTOR('',#2031,1.);
#2031 = DIRECTION('',(1.,0.));
#2032 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
