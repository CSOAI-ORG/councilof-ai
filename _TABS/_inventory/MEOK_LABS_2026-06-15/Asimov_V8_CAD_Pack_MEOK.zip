STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:45',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 12
Bounding box: 60 x 60 x 3 mm (x, y, z)
Volume: 4537.2 mm3; surface area: 6519.6 mm2
Topology: 1 solids, 1 shells, 7 faces, 12 edges, 8 vertices
Faces by surface type: cylinder 4, plane 3
Full cylindrical faces by diameter (mm): 3.4 x2, 50 x1, 60 x1
Entity records: 360 total; most frequent: CARTESIAN_POINT 76, DIRECTION 56, ORIENTED_EDGE 24, PCURVE 24, DEFINITIONAL_REPRESENTATION 24, LINE 20, VECTOR 20, AXIS2_PLACEMENT_3D 16
