STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:45',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 7
Bounding box: 50 x 30 x 4 mm (x, y, z)
Volume: 5260.8 mm3; surface area: 4385.3 mm2
Topology: 1 solids, 1 shells, 40 faces, 102 edges, 68 vertices
Faces by surface type: plane 38, cylinder 2
Full cylindrical faces by diameter (mm): 3.4 x2
Entity records: 2545 total; most frequent: CARTESIAN_POINT 453, DIRECTION 383, LINE 282, VECTOR 282, ORIENTED_EDGE 204, PCURVE 204, DEFINITIONAL_REPRESENTATION 204, EDGE_CURVE 102
