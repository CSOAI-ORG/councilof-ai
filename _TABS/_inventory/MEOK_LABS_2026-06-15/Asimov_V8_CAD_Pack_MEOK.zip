One B-rep face of a CAD part: STEP entity #1340.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#358 = PLANE('',#359);
#359 = AXIS2_PLACEMENT_3D('',#360,#361,#362);
#360 = CARTESIAN_POINT('',(-30.,-20.,100.));
#361 = DIRECTION('',(0.,-1.,0.));
#362 = DIRECTION('',(1.,0.,0.));
#386 = PLANE('',#387);
#387 = AXIS2_PLACEMENT_3D('',#388,#389,#390);
#388 = CARTESIAN_POINT('',(-30.,20.,100.));
#389 = DIRECTION('',(-1.,0.,0.));
#390 = DIRECTION('',(0.,-1.,0.));
#414 = PLANE('',#415);
#415 = AXIS2_PLACEMENT_3D('',#416,#417,#418);
#416 = CARTESIAN_POINT('',(30.,20.,100.));
#417 = DIRECTION('',(0.,1.,-0.));
#418 = DIRECTION('',(-1.,0.,0.));
#440 = PLANE('',#441);
#441 = AXIS2_PLACEMENT_3D('',#442,#443,#444);
#442 = CARTESIAN_POINT('',(30.,-20.,100.));
#443 = DIRECTION('',(1.,0.,0.));
#444 = DIRECTION('',(-0.,1.,0.));
#924 = VERTEX_POINT('',#925);
#925 = CARTESIAN_POINT('',(-30.,-20.,-90.));
#946 = EDGE_CURVE('',#924,#947,#949,.T.);
#947 = VERTEX_POINT('',#948);
#948 = CARTESIAN_POINT('',(30.,-20.,-90.));
#949 = SURFACE_CURVE('',#950,(#954,#961),.PCURVE_S1.);
#950 = LINE('',#951,#952);
#951 = CARTESIAN_POINT('',(-30.,-20.,-90.));
#952 = VECTOR('',#953,1.);
#953 = DIRECTION('',(1.,0.,0.));
#954 = PCURVE('',#358,#955);
#955 = DEFINITIONAL_REPRESENTATION('',(#956),#960);
#956 = LINE('',#957,#958);
#957 = CARTESIAN_POINT('',(0.,-190.));
#958 = VECTOR('',#959,1.);
#959 = DIRECTION('',(1.,0.));
#960 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#961 = PCURVE('',#962,#967);
#962 = PLANE('',#963);
#963 = AXIS2_PLACEMENT_3D('',#964,#965,#966);
#964 = CARTESIAN_POINT('',(0.,0.,-90.));
#965 = DIRECTION('',(0.,0.,1.));
#966 = DIRECTION('',(1.,0.,-0.));
#967 = DEFINITIONAL_REPRESENTATION('',(#968),#972);
#968 = LINE('',#969,#970);
#969 = CARTESIAN_POINT('',(-30.,-20.));
#970 = VECTOR('',#971,1.);
#971 = DIRECTION('',(1.,0.));
#972 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1000 = EDGE_CURVE('',#947,#1001,#1003,.T.);
#1001 = VERTEX_POINT('',#1002);
#1002 = CARTESIAN_POINT('',(30.,20.,-90.));
#1003 = SURFACE_CURVE('',#1004,(#1008,#1015),.PCURVE_S1.);
#1004 = LINE('',#1005,#1006);
#1005 = CARTESIAN_POINT('',(30.,-20.,-90.));
#1006 = VECTOR('',#1007,1.);
#1007 = DIRECTION('',(0.,1.,0.));
#1008 = PCURVE('',#440,#1009);
#1009 = DEFINITIONAL_REPRESENTATION('',(#1010),#1014);
#1010 = LINE('',#1011,#1012);
#1011 = CARTESIAN_POINT('',(0.,-190.));
#1012 = VECTOR('',#1013,1.);
#1013 = DIRECTION('',(1.,0.));
#1014 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1015 = PCURVE('',#962,#1016);
#1016 = DEFINITIONAL_REPRESENTATION('',(#1017),#1021);
#1017 = LINE('',#1018,#1019);
#1018 = CARTESIAN_POINT('',(30.,-20.));
#1019 = VECTOR('',#1020,1.);
#1020 = DIRECTION('',(0.,1.));
#1021 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1049 = EDGE_CURVE('',#1001,#1050,#1052,.T.);
#1050 = VERTEX_POINT('',#1051);
#1051 = CARTESIAN_POINT('',(-30.,20.,-90.));
#1052 = SURFACE_CURVE('',#1053,(#1057,#1064),.PCURVE_S1.);
#1053 = LINE('',#1054,#1055);
#1054 = CARTESIAN_POINT('',(30.,20.,-90.));
#1055 = VECTOR('',#1056,1.);
#1056 = DIRECTION('',(-1.,0.,0.));
#1057 = PCURVE('',#414,#1058);
#1058 = DEFINITIONAL_REPRESENTATION('',(#1059),#1063);
#1059 = LINE('',#1060,#1061);
#1060 = CARTESIAN_POINT('',(0.,-190.));
#1061 = VECTOR('',#1062,1.);
#1062 = DIRECTION('',(1.,0.));
#1063 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1064 = PCURVE('',#962,#1065);
#1065 = DEFINITIONAL_REPRESENTATION('',(#1066),#1070);
#1066 = LINE('',#1067,#1068);
#1067 = CARTESIAN_POINT('',(30.,20.));
#1068 = VECTOR('',#1069,1.);
#1069 = DIRECTION('',(-1.,0.));
#1070 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1098 = EDGE_CURVE('',#1050,#924,#1099,.T.);
#1099 = SURFACE_CURVE('',#1100,(#1104,#1111),.PCURVE_S1.);
#1100 = LINE('',#1101,#1102);
#1101 = CARTESIAN_POINT('',(-30.,20.,-90.));
#1102 = VECTOR('',#1103,1.);
#1103 = DIRECTION('',(0.,-1.,0.));
#1104 = PCURVE('',#386,#1105);
#1105 = DEFINITIONAL_REPRESENTATION('',(#1106),#1110);
#1106 = LINE('',#1107,#1108);
#1107 = CARTESIAN_POINT('',(0.,-190.));
#1108 = VECTOR('',#1109,1.);
#1109 = DIRECTION('',(1.,0.));
#1110 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1111 = PCURVE('',#962,#1112);
#1112 = DEFINITIONAL_REPRESENTATION('',(#1113),#1117);
#1113 = LINE('',#1114,#1115);
#1114 = CARTESIAN_POINT('',(-30.,20.));
#1115 = VECTOR('',#1116,1.);
#1116 = DIRECTION('',(0.,-1.));
#1117 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1340 = ADVANCED_FACE('',(#1341),#962,.T.);
#1341 = FACE_BOUND('',#1342,.T.);
#1342 = EDGE_LOOP('',(#1343,#1344,#1345,#1346));
#1343 = ORIENTED_EDGE('',*,*,#946,.T.);
#1344 = ORIENTED_EDGE('',*,*,#1000,.T.);
#1345 = ORIENTED_EDGE('',*,*,#1049,.T.);
#1346 = ORIENTED_EDGE('',*,*,#1098,.T.);
