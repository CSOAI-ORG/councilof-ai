One B-rep face of a CAD part: STEP entity #681.
In plain terms, this planar face has unit normal (0, -1, 0).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#44 = CYLINDRICAL_SURFACE('',#45,2.);
#45 = AXIS2_PLACEMENT_3D('',#46,#47,#48);
#46 = CARTESIAN_POINT('',(-4.,-23.,-3.));
#47 = DIRECTION('',(0.,0.,1.));
#48 = DIRECTION('',(-1.,-0.,0.));
#72 = PLANE('',#73);
#73 = AXIS2_PLACEMENT_3D('',#74,#75,#76);
#74 = CARTESIAN_POINT('',(-6.,-25.,-3.));
#75 = DIRECTION('',(0.,0.,1.));
#76 = DIRECTION('',(1.,0.,0.));
#143 = VERTEX_POINT('',#144);
#144 = CARTESIAN_POINT('',(-4.,-25.,-3.));
#166 = EDGE_CURVE('',#143,#167,#169,.T.);
#167 = VERTEX_POINT('',#168);
#168 = CARTESIAN_POINT('',(-4.,-25.,2.5));
#169 = SURFACE_CURVE('',#170,(#174,#181),.PCURVE_S1.);
#170 = LINE('',#171,#172);
#171 = CARTESIAN_POINT('',(-4.,-25.,-3.));
#172 = VECTOR('',#173,1.);
#173 = DIRECTION('',(0.,0.,1.));
#174 = PCURVE('',#44,#175);
#175 = DEFINITIONAL_REPRESENTATION('',(#176),#180);
#176 = LINE('',#177,#178);
#177 = CARTESIAN_POINT('',(1.571,0.));
#178 = VECTOR('',#179,1.);
#179 = DIRECTION('',(0.,1.));
#180 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#181 = PCURVE('',#182,#187);
#182 = PLANE('',#183);
#183 = AXIS2_PLACEMENT_3D('',#184,#185,#186);
#184 = CARTESIAN_POINT('',(-6.,-25.,-3.));
#185 = DIRECTION('',(0.,1.,0.));
#186 = DIRECTION('',(0.,0.,1.));
#187 = DEFINITIONAL_REPRESENTATION('',(#188),#192);
#188 = LINE('',#189,#190);
#189 = CARTESIAN_POINT('',(0.,2.));
#190 = VECTOR('',#191,1.);
#191 = DIRECTION('',(1.,0.));
#192 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#303 = EDGE_CURVE('',#143,#304,#306,.T.);
#304 = VERTEX_POINT('',#305);
#305 = CARTESIAN_POINT('',(4.,-25.,-3.));
#306 = SURFACE_CURVE('',#307,(#311,#318),.PCURVE_S1.);
#307 = LINE('',#308,#309);
#308 = CARTESIAN_POINT('',(-6.,-25.,-3.));
#309 = VECTOR('',#310,1.);
#310 = DIRECTION('',(1.,0.,0.));
#311 = PCURVE('',#72,#312);
#312 = DEFINITIONAL_REPRESENTATION('',(#313),#317);
#313 = LINE('',#314,#315);
#314 = CARTESIAN_POINT('',(0.,0.));
#315 = VECTOR('',#316,1.);
#316 = DIRECTION('',(1.,0.));
#317 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#318 = PCURVE('',#182,#319);
#319 = DEFINITIONAL_REPRESENTATION('',(#320),#324);
#320 = LINE('',#321,#322);
#321 = CARTESIAN_POINT('',(0.,0.));
#322 = VECTOR('',#323,1.);
#323 = DIRECTION('',(0.,1.));
#324 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#347 = CYLINDRICAL_SURFACE('',#348,2.);
#348 = AXIS2_PLACEMENT_3D('',#349,#350,#351);
#349 = CARTESIAN_POINT('',(4.,-23.,-3.));
#350 = DIRECTION('',(0.,0.,1.));
#351 = DIRECTION('',(1.,0.,-0.));
#643 = PLANE('',#644);
#644 = AXIS2_PLACEMENT_3D('',#645,#646,#647);
#645 = CARTESIAN_POINT('',(4.,-24.75,2.75));
#646 = DIRECTION('',(0.,0.707,-0.707)
  );
#647 = DIRECTION('',(-1.,0.,0.));
#681 = ADVANCED_FACE('',(#682),#182,.F.);
#682 = FACE_BOUND('',#683,.F.);
#683 = EDGE_LOOP('',(#684,#685,#708,#729));
#684 = ORIENTED_EDGE('',*,*,#166,.T.);
#685 = ORIENTED_EDGE('',*,*,#686,.F.);
#686 = EDGE_CURVE('',#687,#167,#689,.T.);
#687 = VERTEX_POINT('',#688);
#688 = CARTESIAN_POINT('',(4.,-25.,2.5));
#689 = SURFACE_CURVE('',#690,(#694,#701),.PCURVE_S1.);
#690 = LINE('',#691,#692);
#691 = CARTESIAN_POINT('',(4.,-25.,2.5));
#692 = VECTOR('',#693,1.);
#693 = DIRECTION('',(-1.,-0.,-0.));
#694 = PCURVE('',#182,#695);
#695 = DEFINITIONAL_REPRESENTATION('',(#696),#700);
#696 = LINE('',#697,#698);
#697 = CARTESIAN_POINT('',(5.5,10.));
#698 = VECTOR('',#699,1.);
#699 = DIRECTION('',(-0.,-1.));
#700 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#701 = PCURVE('',#643,#702);
#702 = DEFINITIONAL_REPRESENTATION('',(#703),#707);
#703 = LINE('',#704,#705);
#704 = CARTESIAN_POINT('',(0.,-0.354));
#705 = VECTOR('',#706,1.);
#706 = DIRECTION('',(1.,0.));
#707 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#708 = ORIENTED_EDGE('',*,*,#709,.F.);
#709 = EDGE_CURVE('',#304,#687,#710,.T.);
#710 = SURFACE_CURVE('',#711,(#715,#722),.PCURVE_S1.);
#711 = LINE('',#712,#713);
#712 = CARTESIAN_POINT('',(4.,-25.,-3.));
#713 = VECTOR('',#714,1.);
#714 = DIRECTION('',(0.,0.,1.));
#715 = PCURVE('',#182,#716);
#716 = DEFINITIONAL_REPRESENTATION('',(#717),#721);
#717 = LINE('',#718,#719);
#718 = CARTESIAN_POINT('',(0.,10.));
#719 = VECTOR('',#720,1.);
#720 = DIRECTION('',(1.,0.));
#721 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#722 = PCURVE('',#347,#723);
#723 = DEFINITIONAL_REPRESENTATION('',(#724),#728);
#724 = LINE('',#725,#726);
#725 = CARTESIAN_POINT('',(-1.571,0.));
#726 = VECTOR('',#727,1.);
#727 = DIRECTION('',(-0.,1.));
#728 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#729 = ORIENTED_EDGE('',*,*,#303,.F.);
