STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:27',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 21
Bounding box: 35 x 35 x 8 mm (x, y, z)
Volume: 5917.3 mm3; surface area: 3389 mm2
Topology: 1 solids, 1 shells, 35 faces, 91 edges, 58 vertices
Faces by surface type: plane 14, cylinder 13, cone 8
Full cylindrical faces by diameter (mm): 3.4 x4, 22 x1
Entity records: 2477 total; most frequent: CARTESIAN_POINT 729, DIRECTION 308, ORIENTED_EDGE 182, PCURVE 182, DEFINITIONAL_REPRESENTATION 182, LINE 141, VECTOR 141, EDGE_CURVE 91
