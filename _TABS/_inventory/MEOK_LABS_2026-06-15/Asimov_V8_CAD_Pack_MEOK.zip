One B-rep face of a CAD part: STEP entity #17.
In plain terms, this planar face has unit normal (-1, 0, 0).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#17 = ADVANCED_FACE('',(#18,#137,#168,#199,#230),#32,.F.);
#18 = FACE_BOUND('',#19,.F.);
#19 = EDGE_LOOP('',(#20,#55,#83,#111));
#20 = ORIENTED_EDGE('',*,*,#21,.F.);
#21 = EDGE_CURVE('',#22,#24,#26,.T.);
#22 = VERTEX_POINT('',#23);
#23 = CARTESIAN_POINT('',(-1.5,-60.,-125.));
#24 = VERTEX_POINT('',#25);
#25 = CARTESIAN_POINT('',(-1.5,-60.,125.));
#26 = SURFACE_CURVE('',#27,(#31,#43),.PCURVE_S1.);
#27 = LINE('',#28,#29);
#28 = CARTESIAN_POINT('',(-1.5,-60.,-125.));
#29 = VECTOR('',#30,1.);
#30 = DIRECTION('',(0.,0.,1.));
#31 = PCURVE('',#32,#37);
#32 = PLANE('',#33);
#33 = AXIS2_PLACEMENT_3D('',#34,#35,#36);
#34 = CARTESIAN_POINT('',(-1.5,-60.,-125.));
#35 = DIRECTION('',(1.,0.,0.));
#36 = DIRECTION('',(0.,0.,1.));
#37 = DEFINITIONAL_REPRESENTATION('',(#38),#42);
#38 = LINE('',#39,#40);
#39 = CARTESIAN_POINT('',(0.,0.));
#40 = VECTOR('',#41,1.);
#41 = DIRECTION('',(1.,0.));
#42 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#43 = PCURVE('',#44,#49);
#44 = PLANE('',#45);
#45 = AXIS2_PLACEMENT_3D('',#46,#47,#48);
#46 = CARTESIAN_POINT('',(-1.5,-60.,-125.));
#47 = DIRECTION('',(0.,1.,0.));
#48 = DIRECTION('',(0.,0.,1.));
#49 = DEFINITIONAL_REPRESENTATION('',(#50),#54);
#50 = LINE('',#51,#52);
#51 = CARTESIAN_POINT('',(0.,0.));
#52 = VECTOR('',#53,1.);
#53 = DIRECTION('',(1.,0.));
#54 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#55 = ORIENTED_EDGE('',*,*,#56,.T.);
#56 = EDGE_CURVE('',#22,#57,#59,.T.);
#57 = VERTEX_POINT('',#58);
#58 = CARTESIAN_POINT('',(-1.5,60.,-125.));
#59 = SURFACE_CURVE('',#60,(#64,#71),.PCURVE_S1.);
#60 = LINE('',#61,#62);
#61 = CARTESIAN_POINT('',(-1.5,-60.,-125.));
#62 = VECTOR('',#63,1.);
#63 = DIRECTION('',(0.,1.,0.));
#64 = PCURVE('',#32,#65);
#65 = DEFINITIONAL_REPRESENTATION('',(#66),#70);
#66 = LINE('',#67,#68);
#67 = CARTESIAN_POINT('',(0.,0.));
#68 = VECTOR('',#69,1.);
#69 = DIRECTION('',(0.,-1.));
#70 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#71 = PCURVE('',#72,#77);
#72 = PLANE('',#73);
#73 = AXIS2_PLACEMENT_3D('',#74,#75,#76);
#74 = CARTESIAN_POINT('',(-1.5,-60.,-125.));
#75 = DIRECTION('',(0.,0.,1.));
#76 = DIRECTION('',(1.,0.,0.));
#77 = DEFINITIONAL_REPRESENTATION('',(#78),#82);
#78 = LINE('',#79,#80);
#79 = CARTESIAN_POINT('',(0.,0.));
#80 = VECTOR('',#81,1.);
#81 = DIRECTION('',(0.,1.));
#82 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#83 = ORIENTED_EDGE('',*,*,#84,.T.);
#84 = EDGE_CURVE('',#57,#85,#87,.T.);
#85 = VERTEX_POINT('',#86);
#86 = CARTESIAN_POINT('',(-1.5,60.,125.));
#87 = SURFACE_CURVE('',#88,(#92,#99),.PCURVE_S1.);
#88 = LINE('',#89,#90);
#89 = CARTESIAN_POINT('',(-1.5,60.,-125.));
#90 = VECTOR('',#91,1.);
#91 = DIRECTION('',(0.,0.,1.));
#92 = PCURVE('',#32,#93);
#93 = DEFINITIONAL_REPRESENTATION('',(#94),#98);
#94 = LINE('',#95,#96);
#95 = CARTESIAN_POINT('',(0.,-120.));
#96 = VECTOR('',#97,1.);
#97 = DIRECTION('',(1.,0.));
#98 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#99 = PCURVE('',#100,#105);
#100 = PLANE('',#101);
#101 = AXIS2_PLACEMENT_3D('',#102,#103,#104);
#102 = CARTESIAN_POINT('',(-1.5,60.,-125.));
#103 = DIRECTION('',(0.,1.,0.));
#104 = DIRECTION('',(0.,0.,1.));
#105 = DEFINITIONAL_REPRESENTATION('',(#106),#110);
#106 = LINE('',#107,#108);
#107 = CARTESIAN_POINT('',(0.,0.));
#108 = VECTOR('',#109,1.);
#109 = DIRECTION('',(1.,0.));
#110 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#111 = ORIENTED_EDGE('',*,*,#112,.F.);
#112 = EDGE_CURVE('',#24,#85,#113,.T.);
#113 = SURFACE_CURVE('',#114,(#118,#125),.PCURVE_S1.);
#114 = LINE('',#115,#116);
#115 = CARTESIAN_POINT('',(-1.5,-60.,125.));
#116 = VECTOR('',#117,1.);
#117 = DIRECTION('',(0.,1.,0.));
#118 = PCURVE('',#32,#119);
#119 = DEFINITIONAL_REPRESENTATION('',(#120),#124);
#120 = LINE('',#121,#122);
#121 = CARTESIAN_POINT('',(250.,0.));
#122 = VECTOR('',#123,1.);
#123 = DIRECTION('',(0.,-1.));
#124 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#125 = PCURVE('',#126,#131);
#126 = PLANE('',#127);
#127 = AXIS2_PLACEMENT_3D('',#128,#129,#130);
#128 = CARTESIAN_POINT('',(-1.5,-60.,125.));
#129 = DIRECTION('',(0.,0.,1.));
#130 = DIRECTION('',(1.,0.,0.));
#131 = DEFINITIONAL_REPRESENTATION('',(#132),#136);
#132 = LINE('',#133,#134);
#133 = CARTESIAN_POINT('',(0.,0.));
#134 = VECTOR('',#135,1.);
#135 = DIRECTION('',(0.,1.));
#136 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#137 = FACE_BOUND('',#138,.F.);
#138 = EDGE_LOOP('',(#139));
#139 = ORIENTED_EDGE('',*,*,#140,.F.);
#140 = EDGE_CURVE('',#141,#141,#143,.T.);
#141 = VERTEX_POINT('',#142);
#142 = CARTESIAN_POINT('',(-1.5,51.7,-115.));
#143 = SURFACE_CURVE('',#144,(#149,#156),.PCURVE_S1.);
#144 = CIRCLE('',#145,1.7);
#145 = AXIS2_PLACEMENT_3D('',#146,#147,#148);
#146 = CARTESIAN_POINT('',(-1.5,50.,-115.));
#147 = DIRECTION('',(1.,0.,0.));
#148 = DIRECTION('',(0.,1.,0.));
#149 = PCURVE('',#32,#150);
#150 = DEFINITIONAL_REPRESENTATION('',(#151),#155);
#151 = CIRCLE('',#152,1.7);
#152 = AXIS2_PLACEMENT_2D('',#153,#154);
#153 = CARTESIAN_POINT('',(10.,-110.));
#154 = DIRECTION('',(0.,-1.));
#155 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#156 = PCURVE('',#157,#162);
#157 = CYLINDRICAL_SURFACE('',#158,1.7);
#158 = AXIS2_PLACEMENT_3D('',#159,#160,#161);
#159 = CARTESIAN_POINT('',(-1.5,50.,-115.));
#160 = DIRECTION('',(1.,0.,0.));
#161 = DIRECTION('',(0.,1.,0.));
#162 = DEFINITIONAL_REPRESENTATION('',(#163),#167);
#163 = LINE('',#164,#165);
#164 = CARTESIAN_POINT('',(0.,0.));
#165 = VECTOR('',#166,1.);
#166 = DIRECTION('',(1.,0.));
#167 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#168 = FACE_BOUND('',#169,.F.);
#169 = EDGE_LOOP('',(#170));
#170 = ORIENTED_EDGE('',*,*,#171,.F.);
#171 = EDGE_CURVE('',#172,#172,#174,.T.);
#172 = VERTEX_POINT('',#173);
#173 = CARTESIAN_POINT('',(-1.5,51.7,115.));
#174 = SURFACE_CURVE('',#175,(#180,#187),.PCURVE_S1.);
#175 = CIRCLE('',#176,1.7);
#176 = AXIS2_PLACEMENT_3D('',#177,#178,#179);
#177 = CARTESIAN_POINT('',(-1.5,50.,115.));
#178 = DIRECTION('',(1.,0.,0.));
#179 = DIRECTION('',(0.,1.,0.));
#180 = PCURVE('',#32,#181);
#181 = DEFINITIONAL_REPRESENTATION('',(#182),#186);
#182 = CIRCLE('',#183,1.7);
#183 = AXIS2_PLACEMENT_2D('',#184,#185);
#184 = CARTESIAN_POINT('',(240.,-110.));
#185 = DIRECTION('',(0.,-1.));
#186 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#187 = PCURVE('',#188,#193);
#188 = CYLINDRICAL_SURFACE('',#189,1.7);
#189 = AXIS2_PLACEMENT_3D('',#190,#191,#192);
#190 = CARTESIAN_POINT('',(-1.5,50.,115.));
#191 = DIRECTION('',(1.,0.,0.));
#192 = DIRECTION('',(0.,1.,0.));
#193 = DEFINITIONAL_REPRESENTATION('',(#194),#198);
#194 = LINE('',#195,#196);
#195 = CARTESIAN_POINT('',(0.,0.));
#196 = VECTOR('',#197,1.);
#197 = DIRECTION('',(1.,0.));
#198 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#199 = FACE_BOUND('',#200,.F.);
#200 = EDGE_LOOP('',(#201));
#201 = ORIENTED_EDGE('',*,*,#202,.F.);
#202 = EDGE_CURVE('',#203,#203,#205,.T.);
#203 = VERTEX_POINT('',#204);
#204 = CARTESIAN_POINT('',(-1.5,-48.3,-115.));
#205 = SURFACE_CURVE('',#206,(#211,#218),.PCURVE_S1.);
#206 = CIRCLE('',#207,1.7);
#207 = AXIS2_PLACEMENT_3D('',#208,#209,#210);
#208 = CARTESIAN_POINT('',(-1.5,-50.,-115.));
#209 = DIRECTION('',(1.,0.,0.));
#210 = DIRECTION('',(0.,1.,0.));
#211 = PCURVE('',#32,#212);
#212 = DEFINITIONAL_REPRESENTATION('',(#213),#217);
#213 = CIRCLE('',#214,1.7);
#214 = AXIS2_PLACEMENT_2D('',#215,#216);
#215 = CARTESIAN_POINT('',(10.,-10.));
#216 = DIRECTION('',(0.,-1.));
#217 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#218 = PCURVE('',#219,#224);
#219 = CYLINDRICAL_SURFACE('',#220,1.7);
#220 = AXIS2_PLACEMENT_3D('',#221,#222,#223);
#221 = CARTESIAN_POINT('',(-1.5,-50.,-115.));
#222 = DIRECTION('',(1.,0.,0.));
#223 = DIRECTION('',(0.,1.,0.));
#224 = DEFINITIONAL_REPRESENTATION('',(#225),#229);
#225 = LINE('',#226,#227);
#226 = CARTESIAN_POINT('',(0.,0.));
#227 = VECTOR('',#228,1.);
#228 = DIRECTION('',(1.,0.));
#229 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#230 = FACE_BOUND('',#231,.F.);
#231 = EDGE_LOOP('',(#232));
#232 = ORIENTED_EDGE('',*,*,#233,.F.);
#233 = EDGE_CURVE('',#234,#234,#236,.T.);
#234 = VERTEX_POINT('',#235);
#235 = CARTESIAN_POINT('',(-1.5,-48.3,115.));
#236 = SURFACE_CURVE('',#237,(#242,#249),.PCURVE_S1.);
#237 = CIRCLE('',#238,1.7);
#238 = AXIS2_PLACEMENT_3D('',#239,#240,#241);
#239 = CARTESIAN_POINT('',(-1.5,-50.,115.));
#240 = DIRECTION('',(1.,0.,0.));
#241 = DIRECTION('',(0.,1.,0.));
#242 = PCURVE('',#32,#243);
#243 = DEFINITIONAL_REPRESENTATION('',(#244),#248);
#244 = CIRCLE('',#245,1.7);
#245 = AXIS2_PLACEMENT_2D('',#246,#247);
#246 = CARTESIAN_POINT('',(240.,-10.));
#247 = DIRECTION('',(0.,-1.));
#248 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#249 = PCURVE('',#250,#255);
#250 = CYLINDRICAL_SURFACE('',#251,1.7);
#251 = AXIS2_PLACEMENT_3D('',#252,#253,#254);
#252 = CARTESIAN_POINT('',(-1.5,-50.,115.));
#253 = DIRECTION('',(1.,0.,0.));
#254 = DIRECTION('',(0.,1.,0.));
#255 = DEFINITIONAL_REPRESENTATION('',(#256),#260);
#256 = LINE('',#257,#258);
#257 = CARTESIAN_POINT('',(0.,0.));
#258 = VECTOR('',#259,1.);
#259 = DIRECTION('',(1.,0.));
#260 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
