One B-rep face of a CAD part: STEP entity #680.
In plain terms, this planar face has unit normal (0, -1, 0).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#44 = PLANE('',#45);
#45 = AXIS2_PLACEMENT_3D('',#46,#47,#48);
#46 = CARTESIAN_POINT('',(-10.,-12.5,6.));
#47 = DIRECTION('',(0.,0.,1.));
#48 = DIRECTION('',(1.,0.,0.));
#72 = CYLINDRICAL_SURFACE('',#73,2.);
#73 = AXIS2_PLACEMENT_3D('',#74,#75,#76);
#74 = CARTESIAN_POINT('',(-8.,-10.5,-6.));
#75 = DIRECTION('',(0.,0.,1.));
#76 = DIRECTION('',(-1.,-0.,0.));
#100 = PLANE('',#101);
#101 = AXIS2_PLACEMENT_3D('',#102,#103,#104);
#102 = CARTESIAN_POINT('',(-10.,-12.5,-6.));
#103 = DIRECTION('',(0.,0.,1.));
#104 = DIRECTION('',(1.,0.,0.));
#143 = VERTEX_POINT('',#144);
#144 = CARTESIAN_POINT('',(-8.,-12.5,6.));
#166 = EDGE_CURVE('',#143,#167,#169,.T.);
#167 = VERTEX_POINT('',#168);
#168 = CARTESIAN_POINT('',(8.,-12.5,6.));
#169 = SURFACE_CURVE('',#170,(#174,#181),.PCURVE_S1.);
#170 = LINE('',#171,#172);
#171 = CARTESIAN_POINT('',(-10.,-12.5,6.));
#172 = VECTOR('',#173,1.);
#173 = DIRECTION('',(1.,0.,0.));
#174 = PCURVE('',#44,#175);
#175 = DEFINITIONAL_REPRESENTATION('',(#176),#180);
#176 = LINE('',#177,#178);
#177 = CARTESIAN_POINT('',(0.,0.));
#178 = VECTOR('',#179,1.);
#179 = DIRECTION('',(1.,0.));
#180 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#181 = PCURVE('',#182,#187);
#182 = PLANE('',#183);
#183 = AXIS2_PLACEMENT_3D('',#184,#185,#186);
#184 = CARTESIAN_POINT('',(-10.,-12.5,-6.));
#185 = DIRECTION('',(0.,1.,0.));
#186 = DIRECTION('',(0.,0.,1.));
#187 = DEFINITIONAL_REPRESENTATION('',(#188),#192);
#188 = LINE('',#189,#190);
#189 = CARTESIAN_POINT('',(12.,0.));
#190 = VECTOR('',#191,1.);
#191 = DIRECTION('',(0.,1.));
#192 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#215 = CYLINDRICAL_SURFACE('',#216,2.);
#216 = AXIS2_PLACEMENT_3D('',#217,#218,#219);
#217 = CARTESIAN_POINT('',(8.,-10.5,-6.));
#218 = DIRECTION('',(0.,0.,1.));
#219 = DIRECTION('',(1.,0.,-0.));
#456 = VERTEX_POINT('',#457);
#457 = CARTESIAN_POINT('',(-8.,-12.5,-6.));
#479 = EDGE_CURVE('',#456,#143,#480,.T.);
#480 = SURFACE_CURVE('',#481,(#485,#492),.PCURVE_S1.);
#481 = LINE('',#482,#483);
#482 = CARTESIAN_POINT('',(-8.,-12.5,-6.));
#483 = VECTOR('',#484,1.);
#484 = DIRECTION('',(0.,0.,1.));
#485 = PCURVE('',#72,#486);
#486 = DEFINITIONAL_REPRESENTATION('',(#487),#491);
#487 = LINE('',#488,#489);
#488 = CARTESIAN_POINT('',(1.571,0.));
#489 = VECTOR('',#490,1.);
#490 = DIRECTION('',(0.,1.));
#491 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#492 = PCURVE('',#182,#493);
#493 = DEFINITIONAL_REPRESENTATION('',(#494),#498);
#494 = LINE('',#495,#496);
#495 = CARTESIAN_POINT('',(0.,2.));
#496 = VECTOR('',#497,1.);
#497 = DIRECTION('',(1.,0.));
#498 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#561 = EDGE_CURVE('',#456,#562,#564,.T.);
#562 = VERTEX_POINT('',#563);
#563 = CARTESIAN_POINT('',(8.,-12.5,-6.));
#564 = SURFACE_CURVE('',#565,(#569,#576),.PCURVE_S1.);
#565 = LINE('',#566,#567);
#566 = CARTESIAN_POINT('',(-10.,-12.5,-6.));
#567 = VECTOR('',#568,1.);
#568 = DIRECTION('',(1.,0.,0.));
#569 = PCURVE('',#100,#570);
#570 = DEFINITIONAL_REPRESENTATION('',(#571),#575);
#571 = LINE('',#572,#573);
#572 = CARTESIAN_POINT('',(0.,0.));
#573 = VECTOR('',#574,1.);
#574 = DIRECTION('',(1.,0.));
#575 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#576 = PCURVE('',#182,#577);
#577 = DEFINITIONAL_REPRESENTATION('',(#578),#582);
#578 = LINE('',#579,#580);
#579 = CARTESIAN_POINT('',(0.,0.));
#580 = VECTOR('',#581,1.);
#581 = DIRECTION('',(0.,1.));
#582 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#680 = ADVANCED_FACE('',(#681),#182,.F.);
#681 = FACE_BOUND('',#682,.F.);
#682 = EDGE_LOOP('',(#683,#684,#685,#686));
#683 = ORIENTED_EDGE('',*,*,#561,.F.);
#684 = ORIENTED_EDGE('',*,*,#479,.T.);
#685 = ORIENTED_EDGE('',*,*,#166,.T.);
#686 = ORIENTED_EDGE('',*,*,#687,.F.);
#687 = EDGE_CURVE('',#562,#167,#688,.T.);
#688 = SURFACE_CURVE('',#689,(#693,#700),.PCURVE_S1.);
#689 = LINE('',#690,#691);
#690 = CARTESIAN_POINT('',(8.,-12.5,-6.));
#691 = VECTOR('',#692,1.);
#692 = DIRECTION('',(0.,0.,1.));
#693 = PCURVE('',#182,#694);
#694 = DEFINITIONAL_REPRESENTATION('',(#695),#699);
#695 = LINE('',#696,#697);
#696 = CARTESIAN_POINT('',(0.,18.));
#697 = VECTOR('',#698,1.);
#698 = DIRECTION('',(1.,0.));
#699 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#700 = PCURVE('',#215,#701);
#701 = DEFINITIONAL_REPRESENTATION('',(#702),#706);
#702 = LINE('',#703,#704);
#703 = CARTESIAN_POINT('',(-1.571,0.));
#704 = VECTOR('',#705,1.);
#705 = DIRECTION('',(-0.,1.));
#706 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
