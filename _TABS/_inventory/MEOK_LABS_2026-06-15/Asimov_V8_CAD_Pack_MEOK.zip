One B-rep face of a CAD part: STEP entity #576.
In plain terms, this planar face has unit normal (0, -1, 0).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#44 = CYLINDRICAL_SURFACE('',#45,4.);
#45 = AXIS2_PLACEMENT_3D('',#46,#47,#48);
#46 = CARTESIAN_POINT('',(-16.,-26.,-4.));
#47 = DIRECTION('',(0.,0.,1.));
#48 = DIRECTION('',(-1.,-0.,0.));
#72 = PLANE('',#73);
#73 = AXIS2_PLACEMENT_3D('',#74,#75,#76);
#74 = CARTESIAN_POINT('',(-20.,-30.,-4.));
#75 = DIRECTION('',(0.,0.,1.));
#76 = DIRECTION('',(1.,0.,0.));
#143 = VERTEX_POINT('',#144);
#144 = CARTESIAN_POINT('',(-16.,-30.,-4.));
#166 = EDGE_CURVE('',#143,#167,#169,.T.);
#167 = VERTEX_POINT('',#168);
#168 = CARTESIAN_POINT('',(-16.,-30.,3.5));
#169 = SURFACE_CURVE('',#170,(#174,#181),.PCURVE_S1.);
#170 = LINE('',#171,#172);
#171 = CARTESIAN_POINT('',(-16.,-30.,-4.));
#172 = VECTOR('',#173,1.);
#173 = DIRECTION('',(0.,0.,1.));
#174 = PCURVE('',#44,#175);
#175 = DEFINITIONAL_REPRESENTATION('',(#176),#180);
#176 = LINE('',#177,#178);
#177 = CARTESIAN_POINT('',(1.571,0.));
#178 = VECTOR('',#179,1.);
#179 = DIRECTION('',(0.,1.));
#180 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#181 = PCURVE('',#182,#187);
#182 = PLANE('',#183);
#183 = AXIS2_PLACEMENT_3D('',#184,#185,#186);
#184 = CARTESIAN_POINT('',(-20.,-30.,-4.));
#185 = DIRECTION('',(0.,1.,0.));
#186 = DIRECTION('',(0.,0.,1.));
#187 = DEFINITIONAL_REPRESENTATION('',(#188),#192);
#188 = LINE('',#189,#190);
#189 = CARTESIAN_POINT('',(0.,4.));
#190 = VECTOR('',#191,1.);
#191 = DIRECTION('',(1.,0.));
#192 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#303 = EDGE_CURVE('',#143,#304,#306,.T.);
#304 = VERTEX_POINT('',#305);
#305 = CARTESIAN_POINT('',(16.,-30.,-4.));
#306 = SURFACE_CURVE('',#307,(#311,#318),.PCURVE_S1.);
#307 = LINE('',#308,#309);
#308 = CARTESIAN_POINT('',(-20.,-30.,-4.));
#309 = VECTOR('',#310,1.);
#310 = DIRECTION('',(1.,0.,0.));
#311 = PCURVE('',#72,#312);
#312 = DEFINITIONAL_REPRESENTATION('',(#313),#317);
#313 = LINE('',#314,#315);
#314 = CARTESIAN_POINT('',(0.,0.));
#315 = VECTOR('',#316,1.);
#316 = DIRECTION('',(1.,0.));
#317 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#318 = PCURVE('',#182,#319);
#319 = DEFINITIONAL_REPRESENTATION('',(#320),#324);
#320 = LINE('',#321,#322);
#321 = CARTESIAN_POINT('',(0.,0.));
#322 = VECTOR('',#323,1.);
#323 = DIRECTION('',(0.,1.));
#324 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#347 = CYLINDRICAL_SURFACE('',#348,4.);
#348 = AXIS2_PLACEMENT_3D('',#349,#350,#351);
#349 = CARTESIAN_POINT('',(16.,-26.,-4.));
#350 = DIRECTION('',(0.,0.,1.));
#351 = DIRECTION('',(1.,0.,-0.));
#538 = PLANE('',#539);
#539 = AXIS2_PLACEMENT_3D('',#540,#541,#542);
#540 = CARTESIAN_POINT('',(16.,-29.75,3.75));
#541 = DIRECTION('',(0.,0.707,-0.707)
  );
#542 = DIRECTION('',(-1.,0.,0.));
#576 = ADVANCED_FACE('',(#577),#182,.F.);
#577 = FACE_BOUND('',#578,.F.);
#578 = EDGE_LOOP('',(#579,#580,#603,#624));
#579 = ORIENTED_EDGE('',*,*,#166,.T.);
#580 = ORIENTED_EDGE('',*,*,#581,.F.);
#581 = EDGE_CURVE('',#582,#167,#584,.T.);
#582 = VERTEX_POINT('',#583);
#583 = CARTESIAN_POINT('',(16.,-30.,3.5));
#584 = SURFACE_CURVE('',#585,(#589,#596),.PCURVE_S1.);
#585 = LINE('',#586,#587);
#586 = CARTESIAN_POINT('',(16.,-30.,3.5));
#587 = VECTOR('',#588,1.);
#588 = DIRECTION('',(-1.,-0.,-0.));
#589 = PCURVE('',#182,#590);
#590 = DEFINITIONAL_REPRESENTATION('',(#591),#595);
#591 = LINE('',#592,#593);
#592 = CARTESIAN_POINT('',(7.5,36.));
#593 = VECTOR('',#594,1.);
#594 = DIRECTION('',(-0.,-1.));
#595 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#596 = PCURVE('',#538,#597);
#597 = DEFINITIONAL_REPRESENTATION('',(#598),#602);
#598 = LINE('',#599,#600);
#599 = CARTESIAN_POINT('',(0.,-0.354));
#600 = VECTOR('',#601,1.);
#601 = DIRECTION('',(1.,0.));
#602 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#603 = ORIENTED_EDGE('',*,*,#604,.F.);
#604 = EDGE_CURVE('',#304,#582,#605,.T.);
#605 = SURFACE_CURVE('',#606,(#610,#617),.PCURVE_S1.);
#606 = LINE('',#607,#608);
#607 = CARTESIAN_POINT('',(16.,-30.,-4.));
#608 = VECTOR('',#609,1.);
#609 = DIRECTION('',(0.,0.,1.));
#610 = PCURVE('',#182,#611);
#611 = DEFINITIONAL_REPRESENTATION('',(#612),#616);
#612 = LINE('',#613,#614);
#613 = CARTESIAN_POINT('',(0.,36.));
#614 = VECTOR('',#615,1.);
#615 = DIRECTION('',(1.,0.));
#616 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#617 = PCURVE('',#347,#618);
#618 = DEFINITIONAL_REPRESENTATION('',(#619),#623);
#619 = LINE('',#620,#621);
#620 = CARTESIAN_POINT('',(-1.571,0.));
#621 = VECTOR('',#622,1.);
#622 = DIRECTION('',(-0.,1.));
#623 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#624 = ORIENTED_EDGE('',*,*,#303,.F.);
