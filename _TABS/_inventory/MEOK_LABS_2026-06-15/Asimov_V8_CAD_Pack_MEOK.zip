STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:26:43',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 6
Bounding box: 25 x 15 x 10 mm (x, y, z)
Volume: 2995 mm3; surface area: 1851.3 mm2
Topology: 1 solids, 1 shells, 19 faces, 50 edges, 32 vertices
Faces by surface type: plane 13, cylinder 6
Full cylindrical faces by diameter (mm): 3.4 x2
Entity records: 1268 total; most frequent: CARTESIAN_POINT 226, DIRECTION 202, LINE 118, VECTOR 118, ORIENTED_EDGE 100, PCURVE 100, DEFINITIONAL_REPRESENTATION 100, EDGE_CURVE 50
