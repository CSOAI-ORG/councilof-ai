STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:17:59',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 2
Bounding box: 3 x 120 x 250 mm (x, y, z)
Volume: 89891 mm3; surface area: 62275.5 mm2
Topology: 1 solids, 1 shells, 10 faces, 24 edges, 16 vertices
Faces by surface type: plane 6, cylinder 4
Full cylindrical faces by diameter (mm): 3.4 x4
Entity records: 634 total; most frequent: DIRECTION 102, CARTESIAN_POINT 99, LINE 56, VECTOR 56, ORIENTED_EDGE 48, PCURVE 48, DEFINITIONAL_REPRESENTATION 48, EDGE_CURVE 24
