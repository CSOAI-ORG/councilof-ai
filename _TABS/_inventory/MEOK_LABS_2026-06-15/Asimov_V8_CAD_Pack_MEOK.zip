One B-rep face of a CAD part: STEP entity #1168.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#358 = PLANE('',#359);
#359 = AXIS2_PLACEMENT_3D('',#360,#361,#362);
#360 = CARTESIAN_POINT('',(-17.5,-12.5,100.));
#361 = DIRECTION('',(0.,-1.,0.));
#362 = DIRECTION('',(1.,0.,0.));
#386 = PLANE('',#387);
#387 = AXIS2_PLACEMENT_3D('',#388,#389,#390);
#388 = CARTESIAN_POINT('',(-17.5,12.5,100.));
#389 = DIRECTION('',(-1.,0.,0.));
#390 = DIRECTION('',(0.,-1.,0.));
#414 = PLANE('',#415);
#415 = AXIS2_PLACEMENT_3D('',#416,#417,#418);
#416 = CARTESIAN_POINT('',(17.5,12.5,100.));
#417 = DIRECTION('',(0.,1.,-0.));
#418 = DIRECTION('',(-1.,0.,0.));
#440 = PLANE('',#441);
#441 = AXIS2_PLACEMENT_3D('',#442,#443,#444);
#442 = CARTESIAN_POINT('',(17.5,-12.5,100.));
#443 = DIRECTION('',(1.,0.,0.));
#444 = DIRECTION('',(-0.,1.,0.));
#862 = VERTEX_POINT('',#863);
#863 = CARTESIAN_POINT('',(-17.5,-12.5,-90.));
#884 = EDGE_CURVE('',#862,#885,#887,.T.);
#885 = VERTEX_POINT('',#886);
#886 = CARTESIAN_POINT('',(17.5,-12.5,-90.));
#887 = SURFACE_CURVE('',#888,(#892,#899),.PCURVE_S1.);
#888 = LINE('',#889,#890);
#889 = CARTESIAN_POINT('',(-17.5,-12.5,-90.));
#890 = VECTOR('',#891,1.);
#891 = DIRECTION('',(1.,0.,0.));
#892 = PCURVE('',#358,#893);
#893 = DEFINITIONAL_REPRESENTATION('',(#894),#898);
#894 = LINE('',#895,#896);
#895 = CARTESIAN_POINT('',(0.,-190.));
#896 = VECTOR('',#897,1.);
#897 = DIRECTION('',(1.,0.));
#898 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#899 = PCURVE('',#900,#905);
#900 = PLANE('',#901);
#901 = AXIS2_PLACEMENT_3D('',#902,#903,#904);
#902 = CARTESIAN_POINT('',(0.,0.,-90.));
#903 = DIRECTION('',(0.,0.,1.));
#904 = DIRECTION('',(1.,0.,-0.));
#905 = DEFINITIONAL_REPRESENTATION('',(#906),#910);
#906 = LINE('',#907,#908);
#907 = CARTESIAN_POINT('',(-17.5,-12.5));
#908 = VECTOR('',#909,1.);
#909 = DIRECTION('',(1.,0.));
#910 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#938 = EDGE_CURVE('',#885,#939,#941,.T.);
#939 = VERTEX_POINT('',#940);
#940 = CARTESIAN_POINT('',(17.5,12.5,-90.));
#941 = SURFACE_CURVE('',#942,(#946,#953),.PCURVE_S1.);
#942 = LINE('',#943,#944);
#943 = CARTESIAN_POINT('',(17.5,-12.5,-90.));
#944 = VECTOR('',#945,1.);
#945 = DIRECTION('',(0.,1.,0.));
#946 = PCURVE('',#440,#947);
#947 = DEFINITIONAL_REPRESENTATION('',(#948),#952);
#948 = LINE('',#949,#950);
#949 = CARTESIAN_POINT('',(0.,-190.));
#950 = VECTOR('',#951,1.);
#951 = DIRECTION('',(1.,0.));
#952 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#953 = PCURVE('',#900,#954);
#954 = DEFINITIONAL_REPRESENTATION('',(#955),#959);
#955 = LINE('',#956,#957);
#956 = CARTESIAN_POINT('',(17.5,-12.5));
#957 = VECTOR('',#958,1.);
#958 = DIRECTION('',(0.,1.));
#959 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#987 = EDGE_CURVE('',#939,#988,#990,.T.);
#988 = VERTEX_POINT('',#989);
#989 = CARTESIAN_POINT('',(-17.5,12.5,-90.));
#990 = SURFACE_CURVE('',#991,(#995,#1002),.PCURVE_S1.);
#991 = LINE('',#992,#993);
#992 = CARTESIAN_POINT('',(17.5,12.5,-90.));
#993 = VECTOR('',#994,1.);
#994 = DIRECTION('',(-1.,0.,0.));
#995 = PCURVE('',#414,#996);
#996 = DEFINITIONAL_REPRESENTATION('',(#997),#1001);
#997 = LINE('',#998,#999);
#998 = CARTESIAN_POINT('',(0.,-190.));
#999 = VECTOR('',#1000,1.);
#1000 = DIRECTION('',(1.,0.));
#1001 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1002 = PCURVE('',#900,#1003);
#1003 = DEFINITIONAL_REPRESENTATION('',(#1004),#1008);
#1004 = LINE('',#1005,#1006);
#1005 = CARTESIAN_POINT('',(17.5,12.5));
#1006 = VECTOR('',#1007,1.);
#1007 = DIRECTION('',(-1.,0.));
#1008 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1036 = EDGE_CURVE('',#988,#862,#1037,.T.);
#1037 = SURFACE_CURVE('',#1038,(#1042,#1049),.PCURVE_S1.);
#1038 = LINE('',#1039,#1040);
#1039 = CARTESIAN_POINT('',(-17.5,12.5,-90.));
#1040 = VECTOR('',#1041,1.);
#1041 = DIRECTION('',(0.,-1.,0.));
#1042 = PCURVE('',#386,#1043);
#1043 = DEFINITIONAL_REPRESENTATION('',(#1044),#1048);
#1044 = LINE('',#1045,#1046);
#1045 = CARTESIAN_POINT('',(0.,-190.));
#1046 = VECTOR('',#1047,1.);
#1047 = DIRECTION('',(1.,0.));
#1048 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1049 = PCURVE('',#900,#1050);
#1050 = DEFINITIONAL_REPRESENTATION('',(#1051),#1055);
#1051 = LINE('',#1052,#1053);
#1052 = CARTESIAN_POINT('',(-17.5,12.5));
#1053 = VECTOR('',#1054,1.);
#1054 = DIRECTION('',(0.,-1.));
#1055 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#1168 = ADVANCED_FACE('',(#1169),#900,.T.);
#1169 = FACE_BOUND('',#1170,.T.);
#1170 = EDGE_LOOP('',(#1171,#1172,#1173,#1174));
#1171 = ORIENTED_EDGE('',*,*,#884,.T.);
#1172 = ORIENTED_EDGE('',*,*,#938,.T.);
#1173 = ORIENTED_EDGE('',*,*,#987,.T.);
#1174 = ORIENTED_EDGE('',*,*,#1036,.T.);
