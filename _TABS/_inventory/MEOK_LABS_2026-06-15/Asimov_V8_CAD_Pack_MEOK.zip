One B-rep face of a CAD part: STEP entity #198.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#66 = TOROIDAL_SURFACE('',#67,23.,2.);
#67 = AXIS2_PLACEMENT_3D('',#68,#69,#70);
#68 = CARTESIAN_POINT('',(0.,0.,13.));
#69 = DIRECTION('',(0.,0.,1.));
#70 = DIRECTION('',(1.,0.,-0.));
#110 = VERTEX_POINT('',#111);
#111 = CARTESIAN_POINT('',(23.,0.,15.));
#133 = EDGE_CURVE('',#110,#110,#134,.T.);
#134 = SURFACE_CURVE('',#135,(#140,#147),.PCURVE_S1.);
#135 = CIRCLE('',#136,23.);
#136 = AXIS2_PLACEMENT_3D('',#137,#138,#139);
#137 = CARTESIAN_POINT('',(0.,0.,15.));
#138 = DIRECTION('',(0.,0.,1.));
#139 = DIRECTION('',(1.,0.,-0.));
#140 = PCURVE('',#66,#141);
#141 = DEFINITIONAL_REPRESENTATION('',(#142),#146);
#142 = LINE('',#143,#144);
#143 = CARTESIAN_POINT('',(0.,1.571));
#144 = VECTOR('',#145,1.);
#145 = DIRECTION('',(1.,0.));
#146 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#147 = PCURVE('',#148,#153);
#148 = PLANE('',#149);
#149 = AXIS2_PLACEMENT_3D('',#150,#151,#152);
#150 = CARTESIAN_POINT('',(0.,0.,15.));
#151 = DIRECTION('',(0.,0.,1.));
#152 = DIRECTION('',(1.,0.,-0.));
#153 = DEFINITIONAL_REPRESENTATION('',(#154),#158);
#154 = CIRCLE('',#155,23.);
#155 = AXIS2_PLACEMENT_2D('',#156,#157);
#156 = CARTESIAN_POINT('',(0.,0.));
#157 = DIRECTION('',(1.,0.));
#158 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#198 = ADVANCED_FACE('',(#199,#202),#148,.T.);
#199 = FACE_BOUND('',#200,.T.);
#200 = EDGE_LOOP('',(#201));
#201 = ORIENTED_EDGE('',*,*,#133,.T.);
#202 = FACE_BOUND('',#203,.T.);
#203 = EDGE_LOOP('',(#204,#234,#262,#290));
#204 = ORIENTED_EDGE('',*,*,#205,.F.);
#205 = EDGE_CURVE('',#206,#208,#210,.T.);
#206 = VERTEX_POINT('',#207);
#207 = CARTESIAN_POINT('',(-12.,-6.,15.));
#208 = VERTEX_POINT('',#209);
#209 = CARTESIAN_POINT('',(12.,-6.,15.));
#210 = SURFACE_CURVE('',#211,(#215,#222),.PCURVE_S1.);
#211 = LINE('',#212,#213);
#212 = CARTESIAN_POINT('',(-12.,-6.,15.));
#213 = VECTOR('',#214,1.);
#214 = DIRECTION('',(1.,0.,0.));
#215 = PCURVE('',#148,#216);
#216 = DEFINITIONAL_REPRESENTATION('',(#217),#221);
#217 = LINE('',#218,#219);
#218 = CARTESIAN_POINT('',(-12.,-6.));
#219 = VECTOR('',#220,1.);
#220 = DIRECTION('',(1.,0.));
#221 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#222 = PCURVE('',#223,#228);
#223 = PLANE('',#224);
#224 = AXIS2_PLACEMENT_3D('',#225,#226,#227);
#225 = CARTESIAN_POINT('',(-12.,-6.,15.));
#226 = DIRECTION('',(0.,-1.,0.));
#227 = DIRECTION('',(1.,0.,0.));
#228 = DEFINITIONAL_REPRESENTATION('',(#229),#233);
#229 = LINE('',#230,#231);
#230 = CARTESIAN_POINT('',(0.,0.));
#231 = VECTOR('',#232,1.);
#232 = DIRECTION('',(1.,0.));
#233 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#234 = ORIENTED_EDGE('',*,*,#235,.F.);
#235 = EDGE_CURVE('',#236,#206,#238,.T.);
#236 = VERTEX_POINT('',#237);
#237 = CARTESIAN_POINT('',(-12.,6.,15.));
#238 = SURFACE_CURVE('',#239,(#243,#250),.PCURVE_S1.);
#239 = LINE('',#240,#241);
#240 = CARTESIAN_POINT('',(-12.,6.,15.));
#241 = VECTOR('',#242,1.);
#242 = DIRECTION('',(0.,-1.,0.));
#243 = PCURVE('',#148,#244);
#244 = DEFINITIONAL_REPRESENTATION('',(#245),#249);
#245 = LINE('',#246,#247);
#246 = CARTESIAN_POINT('',(-12.,6.));
#247 = VECTOR('',#248,1.);
#248 = DIRECTION('',(0.,-1.));
#249 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#250 = PCURVE('',#251,#256);
#251 = PLANE('',#252);
#252 = AXIS2_PLACEMENT_3D('',#253,#254,#255);
#253 = CARTESIAN_POINT('',(-12.,6.,15.));
#254 = DIRECTION('',(-1.,0.,0.));
#255 = DIRECTION('',(0.,-1.,0.));
#256 = DEFINITIONAL_REPRESENTATION('',(#257),#261);
#257 = LINE('',#258,#259);
#258 = CARTESIAN_POINT('',(0.,0.));
#259 = VECTOR('',#260,1.);
#260 = DIRECTION('',(1.,0.));
#261 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#262 = ORIENTED_EDGE('',*,*,#263,.F.);
#263 = EDGE_CURVE('',#264,#236,#266,.T.);
#264 = VERTEX_POINT('',#265);
#265 = CARTESIAN_POINT('',(12.,6.,15.));
#266 = SURFACE_CURVE('',#267,(#271,#278),.PCURVE_S1.);
#267 = LINE('',#268,#269);
#268 = CARTESIAN_POINT('',(12.,6.,15.));
#269 = VECTOR('',#270,1.);
#270 = DIRECTION('',(-1.,0.,0.));
#271 = PCURVE('',#148,#272);
#272 = DEFINITIONAL_REPRESENTATION('',(#273),#277);
#273 = LINE('',#274,#275);
#274 = CARTESIAN_POINT('',(12.,6.));
#275 = VECTOR('',#276,1.);
#276 = DIRECTION('',(-1.,0.));
#277 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#278 = PCURVE('',#279,#284);
#279 = PLANE('',#280);
#280 = AXIS2_PLACEMENT_3D('',#281,#282,#283);
#281 = CARTESIAN_POINT('',(12.,6.,15.));
#282 = DIRECTION('',(0.,1.,-0.));
#283 = DIRECTION('',(-1.,0.,0.));
#284 = DEFINITIONAL_REPRESENTATION('',(#285),#289);
#285 = LINE('',#286,#287);
#286 = CARTESIAN_POINT('',(0.,0.));
#287 = VECTOR('',#288,1.);
#288 = DIRECTION('',(1.,0.));
#289 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#290 = ORIENTED_EDGE('',*,*,#291,.F.);
#291 = EDGE_CURVE('',#208,#264,#292,.T.);
#292 = SURFACE_CURVE('',#293,(#297,#304),.PCURVE_S1.);
#293 = LINE('',#294,#295);
#294 = CARTESIAN_POINT('',(12.,-6.,15.));
#295 = VECTOR('',#296,1.);
#296 = DIRECTION('',(0.,1.,0.));
#297 = PCURVE('',#148,#298);
#298 = DEFINITIONAL_REPRESENTATION('',(#299),#303);
#299 = LINE('',#300,#301);
#300 = CARTESIAN_POINT('',(12.,-6.));
#301 = VECTOR('',#302,1.);
#302 = DIRECTION('',(0.,1.));
#303 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#304 = PCURVE('',#305,#310);
#305 = PLANE('',#306);
#306 = AXIS2_PLACEMENT_3D('',#307,#308,#309);
#307 = CARTESIAN_POINT('',(12.,-6.,15.));
#308 = DIRECTION('',(1.,0.,0.));
#309 = DIRECTION('',(-0.,1.,0.));
#310 = DEFINITIONAL_REPRESENTATION('',(#311),#315);
#311 = LINE('',#312,#313);
#312 = CARTESIAN_POINT('',(0.,0.));
#313 = VECTOR('',#314,1.);
#314 = DIRECTION('',(1.,0.));
#315 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
