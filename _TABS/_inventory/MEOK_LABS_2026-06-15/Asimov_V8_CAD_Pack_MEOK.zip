STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:16',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 1
Bounding box: 44 x 44 x 20 mm (x, y, z)
Volume: 18256.1 mm3; surface area: 7389.7 mm2
Topology: 1 solids, 1 shells, 9 faces, 20 edges, 12 vertices
Faces by surface type: plane 5, cylinder 4
Full cylindrical faces by diameter (mm): 3.4 x2, 32 x1, 44 x1
Entity records: 536 total; most frequent: DIRECTION 96, CARTESIAN_POINT 82, ORIENTED_EDGE 40, PCURVE 40, DEFINITIONAL_REPRESENTATION 40, CIRCLE 32, LINE 28, VECTOR 28
