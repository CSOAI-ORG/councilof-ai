STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:26:42',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 2
Bounding box: 40 x 35 x 15 mm (x, y, z)
Volume: 17754.3 mm3; surface area: 5282.9 mm2
Topology: 1 solids, 1 shells, 13 faces, 33 edges, 22 vertices
Faces by surface type: plane 7, cylinder 6
Full cylindrical faces by diameter (mm): 16 x1
Entity records: 864 total; most frequent: CARTESIAN_POINT 187, DIRECTION 129, LINE 67, VECTOR 67, ORIENTED_EDGE 66, PCURVE 66, DEFINITIONAL_REPRESENTATION 66, EDGE_CURVE 33
