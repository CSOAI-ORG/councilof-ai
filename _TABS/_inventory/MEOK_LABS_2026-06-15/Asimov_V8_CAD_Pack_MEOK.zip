STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:49',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 2
Bounding box: 80 x 60 x 5 mm (x, y, z)
Volume: 22149.2 mm3; surface area: 12894.5 mm2
Topology: 1 solids, 1 shells, 48 faces, 114 edges, 76 vertices
Faces by surface type: plane 46, cylinder 2
Full cylindrical faces by diameter (mm): 3.4 x2
Entity records: 2874 total; most frequent: CARTESIAN_POINT 491, DIRECTION 440, LINE 334, VECTOR 334, ORIENTED_EDGE 228, PCURVE 228, DEFINITIONAL_REPRESENTATION 228, EDGE_CURVE 114
