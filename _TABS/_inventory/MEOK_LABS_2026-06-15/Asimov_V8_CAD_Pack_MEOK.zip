STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:05:23',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 7
Bounding box: 40 x 40 x 15 mm (x, y, z)
Volume: 16241.7 mm3; surface area: 5591.3 mm2
Topology: 1 solids, 1 shells, 29 faces, 104 edges, 69 vertices
Faces by surface type: cylinder 18, plane 6, torus 5
Full cylindrical faces by diameter (mm): 3.4 x8, 10 x1, 40 x1
Entity records: 3863 total; most frequent: CARTESIAN_POINT 1953, DIRECTION 333, ORIENTED_EDGE 208, PCURVE 208, DEFINITIONAL_REPRESENTATION 208, LINE 113, VECTOR 113, EDGE_CURVE 104
