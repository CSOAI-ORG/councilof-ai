STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:45',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 2
Bounding box: 30 x 3 x 20 mm (x, y, z)
Volume: 1777.2 mm3; surface area: 1526.3 mm2
Topology: 1 solids, 1 shells, 8 faces, 18 edges, 12 vertices
Faces by surface type: plane 6, cylinder 2
Full cylindrical faces by diameter (mm): 2.2 x2
Entity records: 478 total; most frequent: DIRECTION 76, CARTESIAN_POINT 75, LINE 46, VECTOR 46, ORIENTED_EDGE 36, PCURVE 36, DEFINITIONAL_REPRESENTATION 36, EDGE_CURVE 18
