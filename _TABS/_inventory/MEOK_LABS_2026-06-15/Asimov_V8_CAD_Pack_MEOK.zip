One B-rep face of a CAD part: STEP entity #646.
In plain terms, this planar face has unit normal (0, -1, 0).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#44 = CYLINDRICAL_SURFACE('',#45,2.);
#45 = AXIS2_PLACEMENT_3D('',#46,#47,#48);
#46 = CARTESIAN_POINT('',(-4.,-20.5,-3.));
#47 = DIRECTION('',(0.,0.,1.));
#48 = DIRECTION('',(-1.,-0.,0.));
#72 = PLANE('',#73);
#73 = AXIS2_PLACEMENT_3D('',#74,#75,#76);
#74 = CARTESIAN_POINT('',(-6.,-22.5,-3.));
#75 = DIRECTION('',(0.,0.,1.));
#76 = DIRECTION('',(1.,0.,0.));
#143 = VERTEX_POINT('',#144);
#144 = CARTESIAN_POINT('',(-4.,-22.5,-3.));
#166 = EDGE_CURVE('',#143,#167,#169,.T.);
#167 = VERTEX_POINT('',#168);
#168 = CARTESIAN_POINT('',(-4.,-22.5,2.7));
#169 = SURFACE_CURVE('',#170,(#174,#181),.PCURVE_S1.);
#170 = LINE('',#171,#172);
#171 = CARTESIAN_POINT('',(-4.,-22.5,-3.));
#172 = VECTOR('',#173,1.);
#173 = DIRECTION('',(0.,0.,1.));
#174 = PCURVE('',#44,#175);
#175 = DEFINITIONAL_REPRESENTATION('',(#176),#180);
#176 = LINE('',#177,#178);
#177 = CARTESIAN_POINT('',(1.571,0.));
#178 = VECTOR('',#179,1.);
#179 = DIRECTION('',(0.,1.));
#180 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#181 = PCURVE('',#182,#187);
#182 = PLANE('',#183);
#183 = AXIS2_PLACEMENT_3D('',#184,#185,#186);
#184 = CARTESIAN_POINT('',(-6.,-22.5,-3.));
#185 = DIRECTION('',(0.,1.,0.));
#186 = DIRECTION('',(0.,0.,1.));
#187 = DEFINITIONAL_REPRESENTATION('',(#188),#192);
#188 = LINE('',#189,#190);
#189 = CARTESIAN_POINT('',(0.,2.));
#190 = VECTOR('',#191,1.);
#191 = DIRECTION('',(1.,0.));
#192 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#303 = EDGE_CURVE('',#143,#304,#306,.T.);
#304 = VERTEX_POINT('',#305);
#305 = CARTESIAN_POINT('',(4.,-22.5,-3.));
#306 = SURFACE_CURVE('',#307,(#311,#318),.PCURVE_S1.);
#307 = LINE('',#308,#309);
#308 = CARTESIAN_POINT('',(-6.,-22.5,-3.));
#309 = VECTOR('',#310,1.);
#310 = DIRECTION('',(1.,0.,0.));
#311 = PCURVE('',#72,#312);
#312 = DEFINITIONAL_REPRESENTATION('',(#313),#317);
#313 = LINE('',#314,#315);
#314 = CARTESIAN_POINT('',(0.,0.));
#315 = VECTOR('',#316,1.);
#316 = DIRECTION('',(1.,0.));
#317 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#318 = PCURVE('',#182,#319);
#319 = DEFINITIONAL_REPRESENTATION('',(#320),#324);
#320 = LINE('',#321,#322);
#321 = CARTESIAN_POINT('',(0.,0.));
#322 = VECTOR('',#323,1.);
#323 = DIRECTION('',(0.,1.));
#324 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#347 = CYLINDRICAL_SURFACE('',#348,2.);
#348 = AXIS2_PLACEMENT_3D('',#349,#350,#351);
#349 = CARTESIAN_POINT('',(4.,-20.5,-3.));
#350 = DIRECTION('',(0.,0.,1.));
#351 = DIRECTION('',(1.,0.,-0.));
#608 = PLANE('',#609);
#609 = AXIS2_PLACEMENT_3D('',#610,#611,#612);
#610 = CARTESIAN_POINT('',(4.,-22.35,2.85));
#611 = DIRECTION('',(0.,0.707,-0.707)
  );
#612 = DIRECTION('',(-1.,0.,0.));
#646 = ADVANCED_FACE('',(#647),#182,.F.);
#647 = FACE_BOUND('',#648,.F.);
#648 = EDGE_LOOP('',(#649,#650,#673,#694));
#649 = ORIENTED_EDGE('',*,*,#166,.T.);
#650 = ORIENTED_EDGE('',*,*,#651,.F.);
#651 = EDGE_CURVE('',#652,#167,#654,.T.);
#652 = VERTEX_POINT('',#653);
#653 = CARTESIAN_POINT('',(4.,-22.5,2.7));
#654 = SURFACE_CURVE('',#655,(#659,#666),.PCURVE_S1.);
#655 = LINE('',#656,#657);
#656 = CARTESIAN_POINT('',(4.,-22.5,2.7));
#657 = VECTOR('',#658,1.);
#658 = DIRECTION('',(-1.,-0.,-0.));
#659 = PCURVE('',#182,#660);
#660 = DEFINITIONAL_REPRESENTATION('',(#661),#665);
#661 = LINE('',#662,#663);
#662 = CARTESIAN_POINT('',(5.7,10.));
#663 = VECTOR('',#664,1.);
#664 = DIRECTION('',(-0.,-1.));
#665 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#666 = PCURVE('',#608,#667);
#667 = DEFINITIONAL_REPRESENTATION('',(#668),#672);
#668 = LINE('',#669,#670);
#669 = CARTESIAN_POINT('',(0.,-0.212));
#670 = VECTOR('',#671,1.);
#671 = DIRECTION('',(1.,0.));
#672 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#673 = ORIENTED_EDGE('',*,*,#674,.F.);
#674 = EDGE_CURVE('',#304,#652,#675,.T.);
#675 = SURFACE_CURVE('',#676,(#680,#687),.PCURVE_S1.);
#676 = LINE('',#677,#678);
#677 = CARTESIAN_POINT('',(4.,-22.5,-3.));
#678 = VECTOR('',#679,1.);
#679 = DIRECTION('',(0.,0.,1.));
#680 = PCURVE('',#182,#681);
#681 = DEFINITIONAL_REPRESENTATION('',(#682),#686);
#682 = LINE('',#683,#684);
#683 = CARTESIAN_POINT('',(0.,10.));
#684 = VECTOR('',#685,1.);
#685 = DIRECTION('',(1.,0.));
#686 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#687 = PCURVE('',#347,#688);
#688 = DEFINITIONAL_REPRESENTATION('',(#689),#693);
#689 = LINE('',#690,#691);
#690 = CARTESIAN_POINT('',(-1.571,0.));
#691 = VECTOR('',#692,1.);
#692 = DIRECTION('',(-0.,1.));
#693 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#694 = ORIENTED_EDGE('',*,*,#303,.F.);
