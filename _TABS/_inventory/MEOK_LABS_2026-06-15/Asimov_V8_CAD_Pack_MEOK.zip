STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:27:45',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 6
Bounding box: 30 x 25 x 15 mm (x, y, z)
Volume: 9123.3 mm3; surface area: 3767.8 mm2
Topology: 1 solids, 1 shells, 17 faces, 42 edges, 28 vertices
Faces by surface type: plane 11, cylinder 6
Full cylindrical faces by diameter (mm): 3.4 x2
Entity records: 1084 total; most frequent: CARTESIAN_POINT 196, DIRECTION 170, LINE 102, VECTOR 102, ORIENTED_EDGE 84, PCURVE 84, DEFINITIONAL_REPRESENTATION 84, EDGE_CURVE 42
