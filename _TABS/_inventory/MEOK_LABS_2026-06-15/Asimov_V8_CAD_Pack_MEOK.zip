STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:28',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 22
Bounding box: 50 x 15 x 28 mm (x, y, z)
Volume: 10717.4 mm3; surface area: 7256.7 mm2
Topology: 1 solids, 1 shells, 27 faces, 68 edges, 44 vertices
Faces by surface type: plane 19, cylinder 8
Full cylindrical faces by diameter (mm): 3.4 x2, 6.5 x2
Entity records: 1724 total; most frequent: CARTESIAN_POINT 300, DIRECTION 272, LINE 172, VECTOR 172, ORIENTED_EDGE 136, PCURVE 136, DEFINITIONAL_REPRESENTATION 136, EDGE_CURVE 68
