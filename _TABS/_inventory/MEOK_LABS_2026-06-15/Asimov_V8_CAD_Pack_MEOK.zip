STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:26:43',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 12
Bounding box: 15 x 15 x 8 mm (x, y, z)
Volume: 1357 mm3; surface area: 1087 mm2
Topology: 1 solids, 1 shells, 16 faces, 41 edges, 26 vertices
Faces by surface type: plane 9, cylinder 7
Full cylindrical faces by diameter (mm): 2.2 x2, 10 x1
Entity records: 1058 total; most frequent: CARTESIAN_POINT 190, DIRECTION 175, ORIENTED_EDGE 82, PCURVE 82, DEFINITIONAL_REPRESENTATION 82, LINE 79, VECTOR 79, EDGE_CURVE 41
