STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:26:43',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 9
Bounding box: 44 x 44 x 5 mm (x, y, z)
Volume: 2940.5 mm3; surface area: 2664.1 mm2
Topology: 1 solids, 1 shells, 6 faces, 9 edges, 6 vertices
Faces by surface type: cylinder 3, plane 3
Full cylindrical faces by diameter (mm): 32 x1, 36 x1, 44 x1
Entity records: 276 total; most frequent: CARTESIAN_POINT 52, DIRECTION 45, ORIENTED_EDGE 18, PCURVE 18, DEFINITIONAL_REPRESENTATION 18, LINE 15, VECTOR 15, AXIS2_PLACEMENT_3D 13
