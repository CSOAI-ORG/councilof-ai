STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:30:43',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 2
Bounding box: 20 x 20 x 4 mm (x, y, z)
Volume: 907.1 mm3; surface area: 1287.2 mm2
Topology: 1 solids, 1 shells, 11 faces, 30 edges, 20 vertices
Faces by surface type: plane 7, cylinder 4
Full cylindrical faces by diameter (mm): 2.2 x2
Entity records: 762 total; most frequent: CARTESIAN_POINT 142, DIRECTION 116, ORIENTED_EDGE 60, PCURVE 60, DEFINITIONAL_REPRESENTATION 60, LINE 58, VECTOR 58, EDGE_CURVE 30
