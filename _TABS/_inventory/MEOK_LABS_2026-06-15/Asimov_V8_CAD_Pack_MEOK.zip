One B-rep face of a CAD part: STEP entity #815.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#288 = CYLINDRICAL_SURFACE('',#289,9.2);
#289 = AXIS2_PLACEMENT_3D('',#290,#291,#292);
#290 = CARTESIAN_POINT('',(0.,0.,2.));
#291 = DIRECTION('',(0.,0.,1.));
#292 = DIRECTION('',(1.,0.,0.));
#317 = CYLINDRICAL_SURFACE('',#318,1.1);
#318 = AXIS2_PLACEMENT_3D('',#319,#320,#321);
#319 = CARTESIAN_POINT('',(7.,-7.,-2.));
#320 = DIRECTION('',(0.,0.,1.));
#321 = DIRECTION('',(-1.,0.,0.));
#346 = CYLINDRICAL_SURFACE('',#347,9.2);
#347 = AXIS2_PLACEMENT_3D('',#348,#349,#350);
#348 = CARTESIAN_POINT('',(0.,0.,2.));
#349 = DIRECTION('',(0.,0.,1.));
#350 = DIRECTION('',(1.,0.,0.));
#375 = CYLINDRICAL_SURFACE('',#376,1.1);
#376 = AXIS2_PLACEMENT_3D('',#377,#378,#379);
#377 = CARTESIAN_POINT('',(-7.,7.,-2.));
#378 = DIRECTION('',(0.,0.,1.));
#379 = DIRECTION('',(-1.,0.,0.));
#549 = VERTEX_POINT('',#550);
#550 = CARTESIAN_POINT('',(7.058,-5.902,-0.5));
#569 = EDGE_CURVE('',#570,#549,#572,.T.);
#570 = VERTEX_POINT('',#571);
#571 = CARTESIAN_POINT('',(-5.902,7.058,-0.5));
#572 = SURFACE_CURVE('',#573,(#578,#585),.PCURVE_S1.);
#573 = CIRCLE('',#574,9.2);
#574 = AXIS2_PLACEMENT_3D('',#575,#576,#577);
#575 = CARTESIAN_POINT('',(0.,0.,-0.5));
#576 = DIRECTION('',(0.,0.,-1.));
#577 = DIRECTION('',(-0.641,0.767,0.));
#578 = PCURVE('',#288,#579);
#579 = DEFINITIONAL_REPRESENTATION('',(#580),#584);
#580 = LINE('',#581,#582);
#581 = CARTESIAN_POINT('',(8.55,-2.5));
#582 = VECTOR('',#583,1.);
#583 = DIRECTION('',(-1.,-0.));
#584 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#585 = PCURVE('',#586,#591);
#586 = PLANE('',#587);
#587 = AXIS2_PLACEMENT_3D('',#588,#589,#590);
#588 = CARTESIAN_POINT('',(0.,0.,-0.5)
  );
#589 = DIRECTION('',(0.,0.,1.));
#590 = DIRECTION('',(1.,0.,-0.));
#591 = DEFINITIONAL_REPRESENTATION('',(#592),#600);
#592 = ( BOUNDED_CURVE() B_SPLINE_CURVE(2,(#593,#594,#595,#596,#597,#598
,#599),.UNSPECIFIED.,.T.,.F.) B_SPLINE_CURVE_WITH_KNOTS((1,2,2,2,2,1),(
    -2.094,0.,2.094,4.189,6.283,
8.378),.UNSPECIFIED.) CURVE() GEOMETRIC_REPRESENTATION_ITEM() 
RATIONAL_B_SPLINE_CURVE((1.,0.5,1.,0.5,1.,0.5,1.)) REPRESENTATION_ITEM(
  '') );
#593 = CARTESIAN_POINT('',(-5.902,7.058));
#594 = CARTESIAN_POINT('',(6.323,17.279));
#595 = CARTESIAN_POINT('',(9.063,1.582));
#596 = CARTESIAN_POINT('',(11.803,-14.116));
#597 = CARTESIAN_POINT('',(-3.161,-8.64));
#598 = CARTESIAN_POINT('',(-18.126,-3.164));
#599 = CARTESIAN_POINT('',(-5.902,7.058));
#600 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#647 = EDGE_CURVE('',#648,#570,#650,.T.);
#648 = VERTEX_POINT('',#649);
#649 = CARTESIAN_POINT('',(-7.058,5.902,-0.5));
#650 = SURFACE_CURVE('',#651,(#656,#663),.PCURVE_S1.);
#651 = CIRCLE('',#652,1.1);
#652 = AXIS2_PLACEMENT_3D('',#653,#654,#655);
#653 = CARTESIAN_POINT('',(-7.,7.,-0.5));
#654 = DIRECTION('',(0.,0.,1.));
#655 = DIRECTION('',(-1.,0.,0.));
#656 = PCURVE('',#375,#657);
#657 = DEFINITIONAL_REPRESENTATION('',(#658),#662);
#658 = LINE('',#659,#660);
#659 = CARTESIAN_POINT('',(0.,1.5));
#660 = VECTOR('',#661,1.);
#661 = DIRECTION('',(1.,0.));
#662 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#663 = PCURVE('',#586,#664);
#664 = DEFINITIONAL_REPRESENTATION('',(#665),#669);
#665 = CIRCLE('',#666,1.1);
#666 = AXIS2_PLACEMENT_2D('',#667,#668);
#667 = CARTESIAN_POINT('',(-7.,7.));
#668 = DIRECTION('',(-1.,0.));
#669 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#698 = EDGE_CURVE('',#648,#699,#701,.T.);
#699 = VERTEX_POINT('',#700);
#700 = CARTESIAN_POINT('',(5.902,-7.058,-0.5));
#701 = SURFACE_CURVE('',#702,(#707,#714),.PCURVE_S1.);
#702 = CIRCLE('',#703,9.2);
#703 = AXIS2_PLACEMENT_3D('',#704,#705,#706);
#704 = CARTESIAN_POINT('',(0.,0.,-0.5));
#705 = DIRECTION('',(0.,0.,1.));
#706 = DIRECTION('',(1.,0.,0.));
#707 = PCURVE('',#346,#708);
#708 = DEFINITIONAL_REPRESENTATION('',(#709),#713);
#709 = LINE('',#710,#711);
#710 = CARTESIAN_POINT('',(0.,-2.5));
#711 = VECTOR('',#712,1.);
#712 = DIRECTION('',(1.,0.));
#713 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#714 = PCURVE('',#586,#715);
#715 = DEFINITIONAL_REPRESENTATION('',(#716),#720);
#716 = CIRCLE('',#717,9.2);
#717 = AXIS2_PLACEMENT_2D('',#718,#719);
#718 = CARTESIAN_POINT('',(0.,0.));
#719 = DIRECTION('',(1.,0.));
#720 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#746 = EDGE_CURVE('',#747,#699,#749,.T.);
#747 = VERTEX_POINT('',#748);
#748 = CARTESIAN_POINT('',(5.9,-7.,-0.5));
#749 = SURFACE_CURVE('',#750,(#755,#762),.PCURVE_S1.);
#750 = CIRCLE('',#751,1.1);
#751 = AXIS2_PLACEMENT_3D('',#752,#753,#754);
#752 = CARTESIAN_POINT('',(7.,-7.,-0.5));
#753 = DIRECTION('',(0.,0.,1.));
#754 = DIRECTION('',(-1.,0.,0.));
#755 = PCURVE('',#317,#756);
#756 = DEFINITIONAL_REPRESENTATION('',(#757),#761);
#757 = LINE('',#758,#759);
#758 = CARTESIAN_POINT('',(0.,1.5));
#759 = VECTOR('',#760,1.);
#760 = DIRECTION('',(1.,0.));
#761 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#762 = PCURVE('',#586,#763);
#763 = DEFINITIONAL_REPRESENTATION('',(#764),#768);
#764 = CIRCLE('',#765,1.1);
#765 = AXIS2_PLACEMENT_2D('',#766,#767);
#766 = CARTESIAN_POINT('',(7.,-7.));
#767 = DIRECTION('',(-1.,0.));
#768 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#793 = EDGE_CURVE('',#549,#747,#794,.T.);
#794 = SURFACE_CURVE('',#795,(#800,#807),.PCURVE_S1.);
#795 = CIRCLE('',#796,1.1);
#796 = AXIS2_PLACEMENT_3D('',#797,#798,#799);
#797 = CARTESIAN_POINT('',(7.,-7.,-0.5));
#798 = DIRECTION('',(0.,0.,1.));
#799 = DIRECTION('',(-1.,0.,0.));
#800 = PCURVE('',#317,#801);
#801 = DEFINITIONAL_REPRESENTATION('',(#802),#806);
#802 = LINE('',#803,#804);
#803 = CARTESIAN_POINT('',(0.,1.5));
#804 = VECTOR('',#805,1.);
#805 = DIRECTION('',(1.,0.));
#806 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#807 = PCURVE('',#586,#808);
#808 = DEFINITIONAL_REPRESENTATION('',(#809),#813);
#809 = CIRCLE('',#810,1.1);
#810 = AXIS2_PLACEMENT_2D('',#811,#812);
#811 = CARTESIAN_POINT('',(7.,-7.));
#812 = DIRECTION('',(-1.,0.));
#813 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#815 = ADVANCED_FACE('',(#816),#586,.T.);
#816 = FACE_BOUND('',#817,.T.);
#817 = EDGE_LOOP('',(#818,#819,#820,#821,#822));
#818 = ORIENTED_EDGE('',*,*,#793,.F.);
#819 = ORIENTED_EDGE('',*,*,#569,.F.);
#820 = ORIENTED_EDGE('',*,*,#647,.F.);
#821 = ORIENTED_EDGE('',*,*,#698,.T.);
#822 = ORIENTED_EDGE('',*,*,#746,.F.);
