STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(('Open CASCADE Model'),'2;1');
FILE_NAME('Open CASCADE Shape Model','2026-04-19T16:04:22',('Author'),( 'Open CASCADE'),'Open CASCADE STEP processor 7.8','Open CASCADE 7.8' ,'Unknown');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Open CASCADE STEP translator 7.8 2
Bounding box: 150 x 20 x 6 mm (x, y, z)
Volume: 14083.7 mm3; surface area: 8722.8 mm2
Topology: 1 solids, 1 shells, 29 faces, 64 edges, 40 vertices
Faces by surface type: plane 17, cylinder 8, cone 4
Full cylindrical faces by diameter (mm): 5.5 x2, 10 x2
Entity records: 1658 total; most frequent: CARTESIAN_POINT 338, DIRECTION 246, LINE 140, VECTOR 140, ORIENTED_EDGE 128, PCURVE 128, DEFINITIONAL_REPRESENTATION 128, EDGE_CURVE 64
