One B-rep face of a CAD part: STEP entity #190.
In plain terms, this planar face has unit normal (0, 0, 1).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#24 = VERTEX_POINT('',#25);
#25 = CARTESIAN_POINT('',(16.,0.,200.));
#32 = CYLINDRICAL_SURFACE('',#33,16.);
#33 = AXIS2_PLACEMENT_3D('',#34,#35,#36);
#34 = CARTESIAN_POINT('',(0.,0.,0.));
#35 = DIRECTION('',(-0.,-0.,-1.));
#36 = DIRECTION('',(1.,0.,0.));
#51 = EDGE_CURVE('',#24,#24,#52,.T.);
#52 = SURFACE_CURVE('',#53,(#58,#65),.PCURVE_S1.);
#53 = CIRCLE('',#54,16.);
#54 = AXIS2_PLACEMENT_3D('',#55,#56,#57);
#55 = CARTESIAN_POINT('',(0.,0.,200.));
#56 = DIRECTION('',(0.,0.,1.));
#57 = DIRECTION('',(1.,0.,0.));
#58 = PCURVE('',#32,#59);
#59 = DEFINITIONAL_REPRESENTATION('',(#60),#64);
#60 = LINE('',#61,#62);
#61 = CARTESIAN_POINT('',(-0.,-200.));
#62 = VECTOR('',#63,1.);
#63 = DIRECTION('',(-1.,0.));
#64 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#65 = PCURVE('',#66,#71);
#66 = PLANE('',#67);
#67 = AXIS2_PLACEMENT_3D('',#68,#69,#70);
#68 = CARTESIAN_POINT('',(0.,0.,200.));
#69 = DIRECTION('',(0.,0.,1.));
#70 = DIRECTION('',(1.,0.,-0.));
#71 = DEFINITIONAL_REPRESENTATION('',(#72),#76);
#72 = CIRCLE('',#73,16.);
#73 = AXIS2_PLACEMENT_2D('',#74,#75);
#74 = CARTESIAN_POINT('',(0.,0.));
#75 = DIRECTION('',(1.,0.));
#76 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#112 = VERTEX_POINT('',#113);
#113 = CARTESIAN_POINT('',(12.,0.,200.));
#120 = CYLINDRICAL_SURFACE('',#121,12.);
#121 = AXIS2_PLACEMENT_3D('',#122,#123,#124);
#122 = CARTESIAN_POINT('',(0.,0.,0.));
#123 = DIRECTION('',(-0.,-0.,-1.));
#124 = DIRECTION('',(1.,0.,0.));
#139 = EDGE_CURVE('',#112,#112,#140,.T.);
#140 = SURFACE_CURVE('',#141,(#146,#153),.PCURVE_S1.);
#141 = CIRCLE('',#142,12.);
#142 = AXIS2_PLACEMENT_3D('',#143,#144,#145);
#143 = CARTESIAN_POINT('',(0.,0.,200.)
  );
#144 = DIRECTION('',(0.,0.,1.));
#145 = DIRECTION('',(1.,0.,0.));
#146 = PCURVE('',#120,#147);
#147 = DEFINITIONAL_REPRESENTATION('',(#148),#152);
#148 = LINE('',#149,#150);
#149 = CARTESIAN_POINT('',(-0.,-200.));
#150 = VECTOR('',#151,1.);
#151 = DIRECTION('',(-1.,0.));
#152 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#153 = PCURVE('',#66,#154);
#154 = DEFINITIONAL_REPRESENTATION('',(#155),#159);
#155 = CIRCLE('',#156,12.);
#156 = AXIS2_PLACEMENT_2D('',#157,#158);
#157 = CARTESIAN_POINT('',(0.,0.));
#158 = DIRECTION('',(1.,0.));
#159 = ( GEOMETRIC_REPRESENTATION_CONTEXT(2) 
PARAMETRIC_REPRESENTATION_CONTEXT() REPRESENTATION_CONTEXT('2D SPACE',''
  ) );
#190 = ADVANCED_FACE('',(#191,#194),#66,.T.);
#191 = FACE_BOUND('',#192,.T.);
#192 = EDGE_LOOP('',(#193));
#193 = ORIENTED_EDGE('',*,*,#51,.T.);
#194 = FACE_BOUND('',#195,.T.);
#195 = EDGE_LOOP('',(#196));
#196 = ORIENTED_EDGE('',*,*,#139,.F.);
